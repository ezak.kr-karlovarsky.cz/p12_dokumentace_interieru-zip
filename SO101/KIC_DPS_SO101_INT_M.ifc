Properties of the parts of a building model (IFC4), part 2 of 2

# IfcFurniture: Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1 (12)
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm, Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm. Vysunutí zásuvky max. na 75% hloubky. Kontejner je opatřen zámkovým systémem, který centrálně uzavírá a otevírá všechny zásuvky kontejneru a současně blokuje výsuv více než jedné zásuvky.; Typ nábytku: Uzamykatelný mobilní kontejner 3+1; Rozměry: 443/600/602 mm (š/h/v)
Classification: KK (Uniformat)
KIC_PSet - Podlaží: SO101-2NP
Name (Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1:...) | Kód prvku | Označení | Číslo místnosti
4255101 | NK13.01.1003 | 1003 | 2.04
4265105 | NK13.01.1005 | 1005 | 2.06
4265466 | NK13.01.1007 | 1007 | 2.12
4265726 | NK13.01.1008 | 1008 | 2.13
4265946 | NK13.01.1009 | 1009 | 2.14
4266170 | NK13.01.1010 | 1010 | 2.15
4266210 | NK13.01.1011 | 1011 | 2.15
4266918 | NK13.01.1013 | 1013 | 2.20
4267245 | NK13.01.1016 | 1016 | 2.22
4267302 | NK13.01.1018 | 1018 | 2.23
4267427 | NK13.01.1020 | 1020 | 2.24
4267514 | NK13.01.1021 | 1021 | 2.05

# IfcFurniture: Vozík na šanony:P17_Vozík na šanony (2)
In: SO101-2NP
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 17; Konstrukce / Materiály: Kovová konstrukce, která je povrchově upravena práškovým lakem. Čtyři otočná kola se šedým pryžovým běhounem. Police z laminované dřevotřísky o průměru 18 mm, ABS hrana 2 mm.Celková hmotnost 18 kg, celková nosnost 120 kg.; Typ nábytku: Vozík na šanony; Rozměry: 870/390/1030 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP
Name (Vozík na šanony:P17_Vozík na šanony:...) | Kód prvku | Označení | Číslo místnosti
4211320 | NK19.17.1001 | 1001 | 2.07
4213660 | NK19.17.1002 | 1002 | 2.21

# IfcFurniture: Věšák stojanový:P14_Věšák stojanový (6)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 14; Konstrukce / Materiály: Konstrukce z masivního dřeva světlé barvy; Typ nábytku: Věšák stojanový; Rozměry: 510/1760 mm (Ø/v)
Name (Věšák stojanový:P14_Věšák stojanový:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4158049 | SO101-1NP | NK17.14.1001 | 1001 | SO101-1NP | 1.19
4168374 | SO101-1NP | NK17.14.1003 | 1003 | SO101-1NP | 1.03
4181318 | SO101-1NP | NK17.14.1004 | 1004 | SO101-1NP | 1.18
4203181 | SO101-2NP | NK17.14.1005 | 1005 | SO101-2NP | 2.16
4207936 | SO101-2NP | NK17.14.1007 | 1007 | SO101-2NP | 2.20
4207948 | SO101-2NP | NK17.14.1008 | 1008 | SO101-2NP | 2.22

# IfcFurniture: Věšák stojanový:P14_Věšák stojanový (2)
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 14; Konstrukce / Materiály: Konstrukce z masivního dřeva světlé barvy; Typ nábytku: Věšák stojanový; Rozměry: 510/1760 mm (Ø/v)
Classification: P (Uniformat)
Name (Věšák stojanový:P14_Věšák stojanový:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4158055 | SO101-1NP | NK17.14.1002 | 1002 | SO101-1NP | 1.09
4204497 | SO101-2NP | NK17.14.1006 | 1006 | SO101-2NP | 2.01B

# IfcFurniture: Židle jídelní barová exteriérová:EN04_Židle jídelní barová exteriérová (6)
In: SO101-2NP
Type - Classification: EN (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: Konstrukce židle z pozinkované oceli ošetřené práškovou barvou. Hmtnost: 6,1 kg, vhodná pro venkovní použití.; Typ nábytku: Židle barová exteriérová; Rozměry: 465/490/960 mm (š/h/v); výška sedáku: 750 mm
KIC_PSet - Podlaží: SO101-2NP; Číslo místnosti: 2.25
Name (Židle jídelní barová exteriérová:EN04_Židle jídelní barová exteriérová:...) | Kód prvku | Označení
4222652 | NK12.04.1021 | 1021
4222656 | NK12.04.1022 | 1022
4222657 | NK12.04.1023 | 1023
4222658 | NK12.04.1024 | 1024
4222659 | NK12.04.1025 | 1025
4222660 | NK12.04.1026 | 1026

# IfcFurniture: Židle jídelní exteriérová:EN03_Židle jídelní exteriérová (11)
In: SO101-2NP
Type - Classification: EN (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Konstrukce židle z pozinkované oceli ošetřené práškovou barvou. Hmtnost: 5,6 kg. Stohovatelnost: po 10 ks, vhodná pro venkovní použití.; Typ nábytku: Židle jídelní exteriérová; Rozměry: 520/575/800 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP; Číslo místnosti: 2.25
Name (Židle jídelní exteriérová:EN03_Židle jídelní exteriérová:...) | Kód prvku | Označení
4222653 | NK12.03.1001 | 1001
4222663 | NK12.03.1002 | 1002
4222664 | NK12.03.1003 | 1003
4222665 | NK12.03.1004 | 1004
4222666 | NK12.03.1005 | 1005
4222667 | NK12.03.1006 | 1006
4222668 | NK12.03.1007 | 1007
4222669 | NK12.03.1008 | 1008
4222670 | NK12.03.1009 | 1009
4222671 | NK12.03.1010 | 1010
4222672 | NK12.03.1011 | 1011
