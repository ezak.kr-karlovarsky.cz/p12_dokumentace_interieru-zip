Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: 220052
Time: 2023-05-18T10:01:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.5.0.0 - Alternate UI 22.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 18 10:01:21 2023 * Host: EBC-74 * Database: C:\Users\VIT~1.VEV\AppData\Local\Temp\dc923746-f19b-479a-b016-3a60ca5012d0\56b92d23-7491-420e-a88d-1f00a6e0c8be\ifc * Database version: 5507 * Database creation date: Thu May 18 10:01:16 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu May 18 10:01:16 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 18 10:01:16 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 220052
LongName: KARLOVARSKÉ INOVAČNÍ CENTRUM; Phase: DPS

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Podlaží:Podlaží (2)
Name | LongName | Elevation (mm)
SO101-1NP | SO101-1NP | 0
SO101-2NP | SO101-2NP | 4200

# IfcFurniture: Barová židle:Z05A_ Barová židle (2)
In: SO101-2NP
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 05A; Konstrukce / Materiály: 4-nohá dřevěná podnož z masivního dřeva, bez kluzáků, dřevěný korpus překližka, barevný lak, hmotnost 5,2 kg; Typ nábytku: Barová židle; Rozměry: Celkové: 490/479/994 mm (š/h/v); Sedadlo: 440/360/780 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP; Číslo místnosti: 2.01B
Name (Barová židle:Z05A_ Barová židle:...) | Kód prvku | Označení
4204857 | NK12.05A.1001 | 1001
4204858 | NK12.05A.1002 | 1002

# IfcFurniture: Barová židle:Z05B_Barová židle (2)
In: SO101-2NP
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 05B; Konstrukce / Materiály: 4-nohá dřevěná podnož z masivního dřeva, bez kluzáků, dřevěný korpus překližka, barevný lak, hmotnost 5,2 kg; Typ nábytku: Barová židle; Rozměry: Celkové: 490/479/994 mm (š/h/v); Sedadlo: 440/360/780 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP; Číslo místnosti: 2.01B
Name (Barová židle:Z05B_Barová židle:...) | Kód prvku | Označení
4204911 | NK12.05B.1001 | 1001
4204912 | NK12.05B.1002 | 1002

# IfcFurniture: Barová židle:Z05_Barová židle (5)
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 05; Konstrukce / Materiály: 4-nohá dřevěná podnož ze světlého masivního dřeva, bez kluzáků, hmotnost 5,2 kg, dřevěný korpus.; Typ nábytku: Barová židle; Rozměry: Celkové: 490/479/994 mm (š/h/v); Sedadlo: 440/360/780 mm (š/h/v)
Name (Barová židle:Z05_Barová židle:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4155303 | SO101-1NP | NK12.05.1001 | 1001 | SO101-1NP | 1.09
4155340 | SO101-1NP | NK12.05.1002 | 1002 | SO101-1NP | 1.09
4155350 | SO101-1NP | NK12.05.1003 | 1003 | SO101-1NP | 1.09
4204815 | SO101-2NP | NK12.05.1004 | 1004 | SO101-2NP | 2.01B
4204849 | SO101-2NP | NK12.05.1005 | 1005 | SO101-2NP | 2.01B

# IfcFurniture: Barový stůl exteriérový:EN01_Barový stůl exteriérový (3)
In: SO101-2NP
Type - Classification: EN (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Konstrukce čtřnohé podnože - ocelová pozinkovaná a ošetřená barvou v laku. Vysoce odolná kompaktní HPL deska odolná proti vlhkosti. Hmotnost: 18 kg. Vhodný pro venkovní použití.; Typ nábytku: Barový stůl; Rozměry: 1200/500/1100 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP; Číslo místnosti: 2.25
Name (Barový stůl exteriérový:EN01_Barový stůl exteriérový:...) | Kód prvku | Označení
4222651 | NK11.01.1001 | 1001
4222654 | NK11.01.1002 | 1002
4222655 | NK11.01.1003 | 1003

# IfcFurniture: Barový stůl:S10_Barový stůl (2)
In: SO101-2NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 10; Konstrukce / Materiály: Deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Podnoží z masivního dřeva světlé barvy; Typ nábytku: Barový stůl; Rozměry: 1800/600/1100 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP; Číslo místnosti: 2.01B
Name (Barový stůl:S10_Barový stůl:...) | Kód prvku | Označení
4204774 | NK11.10.1001 | 1001
4204806 | NK11.10.1002 | 1002

# IfcFurniture: Barový stůl:S11_Barový stůl, Barový stůl:S11_Barový stůl:4154264
In: SO101-1NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 11; Konstrukce / Materiály: Deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Podnoží z masivního dřeva světlé barvy; Typ nábytku: Barový stůl; Rozměry: 2000/600/1100 mm (š/h/v)
KIC_PSet - Kód prvku: NK11.11.1001; Označení: 1001; Podlaží: SO101-1NP; Číslo místnosti: 1.09

# IfcFurniture: DVERE-Tabule:informační tabulka (17)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Tabulka se skládá z profilu ze stříbrně eloxovaného hliníku, který je zakončen plastovými bočnicemi šedé barvy. Části se do sebe jednoduše zaklapují. Do profilu se vkládá papírový výtisk chráněný krycím antireflexním plastem nebo gravírovaný pásek z umělé hmoty anebo kovový pásek s natištěnými informacemi. Tabulku je možno dle podkladu přišroubovat nebo přilepit pomocí oboustranné lepenky. V plastových bočnicích jsou otvory pro přišroubování.; Typ nábytku: Informační tabulka; Rozměry: 187/62 mm (š/v)
Name (DVERE-Tabule:informační tabulka:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4369973 | SO101-2NP | NK25.02.1001 | 1001 | SO101-2NP | 2.04
4371201 | SO101-2NP | NK25.02.1002 | 1002 | SO101-2NP | 2.05
4371215 | SO101-2NP | NK25.02.1003 | 1003 | SO101-2NP | 2.06
4371231 | SO101-2NP | NK25.02.1004 | 1004 | SO101-2NP | 2.07
4371247 | SO101-2NP | NK25.02.1005 | 1005 | SO101-2NP | 2.12
4371299 | SO101-2NP | NK25.02.1006 | 1006 | SO101-2NP | 2.13
4371311 | SO101-2NP | NK25.02.1007 | 1007 | SO101-2NP | 2.14
4371337 | SO101-2NP | NK25.02.1008 | 1008 | SO101-2NP
4371357 | SO101-2NP | NK25.02.1009 | 1009 | SO101-2NP | 2.16
4371365 | SO101-2NP | NK25.02.1010 | 1010 | SO101-2NP | 2.15
4371389 | SO101-2NP | NK25.02.1011 | 1011 | SO101-2NP | 2.22
4371417 | SO101-2NP | NK25.02.1012 | 1012 | SO101-2NP | 2.23
4371431 | SO101-2NP | NK25.02.1013 | 1013 | SO101-2NP | 2.24
4371672 | SO101-2NP | NK25.02.1014 | 1014 | SO101-2NP | 2.21
4371713 | SO101-2NP | NK25.02.1015 | 1015 | SO101-2NP | 2.20
4372687 | SO101-1NP | NK25.02.1016 | 1016 | SO101-1NP | 1.09
4372722 | SO101-1NP | NK25.02.1017 | 1017 | SO101-1NP | 1.18

# IfcFurniture: INFO-Tabule:Hlavní orientační tabule (2)
In: SO101-1NP
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Tabule ze stříbrně eloxovaného hliníkového systému. Jednotlivé profily jsou do sebe zacvaknuty. Hliníkové bočnice jsou ze stejného materiálu i stejné barvy. Na horním i dolním konci obou bočnic jsou přišroubovány černé plastové krytky. Celá hlavní orientační tabule je nalepena na nosné plastové desce, v které jsou vyvrtány otvory pro montáž celého panelu na zeď. Informační text je řešen polepením fóliovou grafikou dle požadavků.; Typ nábytku: Hlavní orientační tabule; Rozměry: 1218/656 mm (š/v)
KIC_PSet - Podlaží: SO101-1NP
Name (INFO-Tabule:Hlavní orientační tabule:...) | Kód prvku | Označení | Číslo místnosti
4372748 | NK25.01.1001 | 1001 | 1.02
4373640 | NK25.01.1002 | 1002 | 1.15

# IfcFurniture: Jednací křeslo:SN04_Jednací křeslo (2)
In: SO101-2NP
Type - Classification: SN Stěny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: Dvojmístné křeslo, podnož chromovaná, celočalouněný korpus. Tloušťka opěráku 50 mm, Tloušťka bočnic 50 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Jednací křeslo; Rozměry: 1200/650/1200 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP; Číslo místnosti: 2.01C
Name (Jednací křeslo:SN04_Jednací křeslo:...) | Kód prvku | Označení
4214741 | NK04.04.1001 | 1001
4214768 | NK04.04.1002 | 1002

# IfcFurniture: Jednací křeslo:SN05_Jednací křeslo, Jednací křeslo:SN05_Jednací křeslo:4214828
In: SO101-2NP
Type - Classification: SN Stěny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 05; Konstrukce / Materiály: Dvojmístné křeslo, podnož chromovaná, celočalouněný korpus. Tloušťka opěráku 50 mm, Tloušťka bočnic 50 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Jednací křeslo; Rozměry: 1600/650/1200 mm (š/h/v)
KIC_PSet - Kód prvku: NK04.05.1001; Označení: 1001; Podlaží: SO101-2NP; Číslo místnosti: 2.01E

# IfcFurniture: Jednací stůl stohovatelný - sklopný:S03_Jednací stůl stohovatelný - sklopný (10)
In: SO101-1NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Do řad stohovatelný, sklopný stůl na kolečkách s brzdou, Kovový rám se sklápěcím mechanismem, podnož na kolečkách; Typ nábytku: Jednací stůl stohovatelný - sklopný; Rozměry: 1400/800/725 mm (š/h/v)
KIC_PSet - Podlaží: SO101-1NP
Name (Jednací stůl stohovatelný - sklopný:S03_Jednací stůl stohovatelný - sklopný:...) | Kód prvku | Označení | Číslo místnosti
4182513 | NK03.03.1001 | 1001 | 1.18
4182715 | NK03.03.1002 | 1002 | 1.18
4182733 | NK03.03.1003 | 1003 | 1.18
4182747 | NK03.03.1004 | 1004 | 1.18
4182842 | NK03.03.1009 | 1009 | 1.18
4184191 | NK03.03.1011 | 1011 | 1.17
4184192 | NK03.03.1012 | 1012 | 1.17
4184193 | NK03.03.1013 | 1013 | 1.17
4184194 | NK03.03.1014 | 1014 | 1.17
4184199 | NK03.03.1019 | 1019 | 1.17

# IfcFurniture: Jednací stůl stohovatelný - sklopný:S03_Jednací stůl stohovatelný - sklopný (10)
In: SO101-1NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Do řad stohovatelný, sklopný stůl na kolečkách s brzdou, Kovový rám se sklápěcím mechanismem, podnož na kolečkách; Typ nábytku: Jednací stůl stohovatelný - sklopný; Rozměry: 1400/800/725 mm (š/h/v)
Classification: S (Uniformat)
KIC_PSet - Podlaží: SO101-1NP
Name (Jednací stůl stohovatelný - sklopný:S03_Jednací stůl stohovatelný - sklopný:...) | Kód prvku | Označení | Číslo místnosti
4182765 | NK03.03.1005 | 1005 | 1.18
4182766 | NK03.03.1006 | 1006 | 1.18
4182767 | NK03.03.1007 | 1007 | 1.18
4182768 | NK03.03.1008 | 1008 | 1.18
4182881 | NK03.03.1010 | 1010 | 1.18
4184195 | NK03.03.1015 | 1015 | 1.17
4184196 | NK03.03.1016 | 1016 | 1.17
4184197 | NK03.03.1017 | 1017 | 1.17
4184198 | NK03.03.1018 | 1018 | 1.17
4184200 | NK03.03.1020 | 1020 | 1.17

# IfcFurniture: Jídelní stůl kulatý:S07_Jídelní stůl (4)
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 07; Konstrukce / Materiály: Deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Podnoží z masivního dřeva světlé barvy 4 nohy.; Typ nábytku: Jídelní stůl; Rozměry: 900/750 mm (Ø/v)
Name (Jídelní stůl kulatý:S07_Jídelní stůl:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4173247 | SO101-1NP | NK11.07.1001 | 1001 | SO101-1NP | 1.19
4206911 | SO101-2NP | NK11.07.1002 | 1002 | SO101-2NP | 2.01B
4206952 | SO101-2NP | NK11.07.1003 | 1003 | SO101-2NP | 2.01B
4206993 | SO101-2NP | NK11.07.1004 | 1004 | SO101-2NP | 2.01B

# IfcFurniture: Jídelní stůl:S08_Jídelní stůl, Jídelní stůl:S08_Jídelní stůl:4174169
In: SO101-1NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 08; Konstrukce / Materiály: Deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Podnoží z masivního dřeva světlé barvy; Typ nábytku: Jídelní stůl; Rozměry: 2000/800/750 mm (š/h/v)
KIC_PSet - Kód prvku: NK11.08.1001; Označení: 1001; Podlaží: SO101-1NP; Číslo místnosti: 1.19

# IfcFurniture: Jídelní stůl:S09_Jídelní stůl, Jídelní stůl:S09_Jídelní stůl:4214866
In: SO101-2NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 09; Konstrukce / Materiály: Deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Podnoží z masivního dřeva světlé barvy; Typ nábytku: Jídelní stůl; Rozměry: 2000/800/750 mm (š/h/v)
KIC_PSet - Kód prvku: NK11.09.1001; Označení: 1001; Podlaží: SO101-2NP; Číslo místnosti: 2.01D

# IfcFurniture: Jídelní židle:Z04A_Jídelní židle, Jídelní židle:Z04A_Jídelní židle:4205920
In: SO101-2NP
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04A; Konstrukce / Materiály: 4-nohá dřevěná podnož z masivního dřeva, bez kluzáků, dřevěný korpus překližka, barevný lak, hmotnost 4,6 kg; Typ nábytku: Jídelní židle; Rozměry: Celkové: 490/525/790 mm (š/h/v); Sedadlo: 436/420/450 mm (š/h/v)
KIC_PSet - Kód prvku: NK12.04A.1001; Označení: 1001; Podlaží: SO101-2NP; Číslo místnosti: 2.01B

# IfcFurniture: Jídelní židle:Z04B_Jídelní židle, Jídelní židle:Z04B_Jídelní židle:4205956
In: SO101-2NP
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04B; Konstrukce / Materiály: 4-nohá dřevěná podnož z masivního dřeva, bez kluzáků, dřevěný korpus překližka, barevný lak, hmotnost 4,6 kg; Typ nábytku: Jídelní židle; Rozměry: Celkové: 490/525/790 mm (š/h/v); Sedadlo: 436/420/450 mm (š/h/v)
KIC_PSet - Kód prvku: NK12.04B.1001; Označení: 1001; Podlaží: SO101-2NP; Číslo místnosti: 2.01B

# IfcFurniture: Jídelní židle:Z04_Jídelní židle (20)
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: 4-nohá dřevěná podnož ze světlého masivního dřeva, bez kluzáků, dřevěný korpus překližka, bezbarvý lak, hmotnost 4,6 kg; Typ nábytku: Jídelní židle; Rozměry: Celkové: 490/525/790 mm (š/h/v); Sedadlo: 436/420/450 mm (š/h/v)
Name (Jídelní židle:Z04_Jídelní židle:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4175164 | SO101-1NP | NK12.04.1001 | 1001 | SO101-1NP | 1.19
4175248 | SO101-1NP | NK12.04.1002 | 1002 | SO101-1NP | 1.19
4175275 | SO101-1NP | NK12.04.1003 | 1003 | SO101-1NP | 1.19
4175276 | SO101-1NP | NK12.04.1004 | 1004 | SO101-1NP | 1.19
4175320 | SO101-1NP | NK12.04.1005 | 1005 | SO101-1NP | 1.19
4175367 | SO101-1NP | NK12.04.1006 | 1006 | SO101-1NP | 1.19
4175381 | SO101-1NP | NK12.04.1007 | 1007 | SO101-1NP | 1.19
4175395 | SO101-1NP | NK12.04.1008 | 1008 | SO101-1NP | 1.19
4175396 | SO101-1NP | NK12.04.1009 | 1009 | SO101-1NP | 1.19
4175397 | SO101-1NP | NK12.04.1010 | 1010 | SO101-1NP | 1.19
4204556 | SO101-2NP | NK12.04.1011 | 1011 | SO101-2NP | 2.01B
4204603 | SO101-2NP | NK12.04.1012 | 1012 | SO101-2NP | 2.01B
4204642 | SO101-2NP | NK12.04.1013 | 1013 | SO101-2NP | 2.01B
4204652 | SO101-2NP | NK12.04.1014 | 1014 | SO101-2NP | 2.01B
4214906 | SO101-2NP | NK12.04.1015 | 1015 | SO101-2NP | 2.01D
4214932 | SO101-2NP | NK12.04.1016 | 1016 | SO101-2NP | 2.01D
4214962 | SO101-2NP | NK12.04.1017 | 1017 | SO101-2NP | 2.01D
4214984 | SO101-2NP | NK12.04.1018 | 1018 | SO101-2NP | 2.01D
4214985 | SO101-2NP | NK12.04.1019 | 1019 | SO101-2NP | 2.01D
4214986 | SO101-2NP | NK12.04.1020 | 1020 | SO101-2NP | 2.01D

# IfcFurniture: Kancelářská židle:Z01_Kancelářská židle (57)
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Nastavitelná výška křesla, s černými pevnými područkami z formované pěny, područky výškově nastavitelné, celočalouněným sedákem a síťovanou opěrou zad. Podnož z leštěného hliníku s pěti rameny, černá kolečka. Čalounění: složení: 97,9% Polyester, 2,1% Spendex. Gramáž: 263,9 g/m2.; Typ nábytku: Kancelářská židle; Rozměry: 700/470/1160-1240 mm (š/h/v)
Name (Kancelářská židle:Z01_Kancelářská židle:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4149686 | SO101-1NP | NK02.01.1001 | 1001 | SO101-1NP | 1.09
4150665 | SO101-1NP | NK02.01.1002 | 1002 | SO101-1NP | 1.09
4150843 | SO101-1NP | NK02.01.1003 | 1003 | SO101-1NP | 1.09
4151123 | SO101-1NP | NK02.01.1004 | 1004 | SO101-1NP | 1.03
4197644 | SO101-2NP | NK02.01.1005 | 1005 | SO101-2NP | 2.04
4217864 | SO101-1NP | NK02.01.1006 | 1006 | SO101-1NP | 1.18
4217891 | SO101-1NP | NK02.01.1007 | 1007 | SO101-1NP | 1.18
4217919 | SO101-1NP | NK02.01.1008 | 1008 | SO101-1NP | 1.18
4217927 | SO101-1NP | NK02.01.1009 | 1009 | SO101-1NP | 1.18
4217935 | SO101-1NP | NK02.01.1010 | 1010 | SO101-1NP | 1.18
4217949 | SO101-1NP | NK02.01.1011 | 1011 | SO101-1NP | 1.18
4217970 | SO101-1NP | NK02.01.1012 | 1012 | SO101-1NP | 1.18
4217971 | SO101-1NP | NK02.01.1013 | 1013 | SO101-1NP | 1.18
4217972 | SO101-1NP | NK02.01.1014 | 1014 | SO101-1NP | 1.18
4218000 | SO101-1NP | NK02.01.1015 | 1015 | SO101-1NP | 1.18
4218018 | SO101-1NP | NK02.01.1016 | 1016 | SO101-1NP | 1.17
4218019 | SO101-1NP | NK02.01.1017 | 1017 | SO101-1NP | 1.17
4218024 | SO101-1NP | NK02.01.1018 | 1018 | SO101-1NP | 1.17
4218025 | SO101-1NP | NK02.01.1019 | 1019 | SO101-1NP | 1.17
4218026 | SO101-1NP | NK02.01.1020 | 1020 | SO101-1NP | 1.17
4218061 | SO101-1NP | NK02.01.1021 | 1021 | SO101-1NP | 1.17
4218062 | SO101-1NP | NK02.01.1022 | 1022 | SO101-1NP | 1.17
4218063 | SO101-1NP | NK02.01.1023 | 1023 | SO101-1NP | 1.17
4218064 | SO101-1NP | NK02.01.1024 | 1024 | SO101-1NP | 1.17
4218065 | SO101-1NP | NK02.01.1025 | 1025 | SO101-1NP | 1.17
4255353 | SO101-2NP | NK02.01.1026 | 1026 | SO101-2NP | 2.15
4261111 | SO101-1NP | NK02.01.1027 | 1027 | SO101-1NP | 1.09
4261158 | SO101-1NP | NK02.01.1028 | 1028 | SO101-1NP | 1.09
4261293 | SO101-1NP | NK02.01.1029 | 1029 | SO101-1NP | 1.09
4261310 | SO101-1NP | NK02.01.1030 | 1030 | SO101-1NP | 1.09
4261324 | SO101-1NP | NK02.01.1031 | 1031 | SO101-1NP | 1.09
4261341 | SO101-1NP | NK02.01.1032 | 1032 | SO101-1NP | 1.09
4261359 | SO101-1NP | NK02.01.1033 | 1033 | SO101-1NP | 1.09
4261375 | SO101-1NP | NK02.01.1034 | 1034 | SO101-1NP | 1.09
4261394 | SO101-1NP | NK02.01.1035 | 1035 | SO101-1NP | 1.09
4261407 | SO101-1NP | NK02.01.1036 | 1036 | SO101-1NP | 1.09
4261422 | SO101-1NP | NK02.01.1037 | 1037 | SO101-1NP | 1.09
4264903 | SO101-2NP | NK02.01.1038 | 1038 | SO101-2NP | 2.04
4265101 | SO101-2NP | NK02.01.1039 | 1039 | SO101-2NP | 2.06
4265109 | SO101-2NP | NK02.01.1040 | 1040 | SO101-2NP | 2.06
4265462 | SO101-2NP | NK02.01.1041 | 1041 | SO101-2NP | 2.12
4265470 | SO101-2NP | NK02.01.1042 | 1042 | SO101-2NP | 2.12
4265722 | SO101-2NP | NK02.01.1043 | 1043 | SO101-2NP | 2.13
4265944 | SO101-2NP | NK02.01.1044 | 1044 | SO101-2NP | 2.14
4266168 | SO101-2NP | NK02.01.1045 | 1045 | SO101-2NP | 2.15
4266208 | SO101-2NP | NK02.01.1046 | 1046 | SO101-2NP | 2.15
4266916 | SO101-2NP | NK02.01.1047 | 1047 | SO101-2NP | 2.20
4266980 | SO101-2NP | NK02.01.1048 | 1048 | SO101-2NP | 2.20
4267122 | SO101-2NP | NK02.01.1049 | 1049 | SO101-2NP | 2.22
4267243 | SO101-2NP | NK02.01.1050 | 1050 | SO101-2NP | 2.22
4267262 | SO101-2NP | NK02.01.1051 | 1051 | SO101-2NP | 2.23
4267300 | SO101-2NP | NK02.01.1052 | 1052 | SO101-2NP | 2.23
4267392 | SO101-2NP | NK02.01.1053 | 1053 | SO101-2NP | 2.24
4267425 | SO101-2NP | NK02.01.1054 | 1054 | SO101-2NP | 2.24
4267512 | SO101-2NP | NK02.01.1055 | 1055 | SO101-2NP | 2.05
4267566 | SO101-2NP | NK02.01.1056 | 1056 | SO101-2NP | 2.05
4346344 | SO101-1NP | NK02.01.1057 | 1057 | SO101-1NP | 1.09

# IfcFurniture: Kancelářský koš:P01_Kancelářský koš (12)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Neuzavíratelný, ocelový, potažený epoxidovou pryskyřicí odolnou proti poškrábání, objem 15 l; Typ nábytku: Kancelářský koš; Rozměry: 260/315 mm (Ø/v)
Name (Kancelářský koš:P01_Kancelářský koš:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4170250 | SO101-1NP | NK14.01.1001 | 1001 | SO101-1NP | 1.03
4187626 | SO101-1NP | NK14.01.1002 | 1002 | SO101-1NP | 1.14
4197660 | SO101-2NP | NK14.01.1003 | 1003 | SO101-2NP | 2.04
4204205 | SO101-2NP | NK14.01.1004 | 1004 | SO101-2NP | 2.16
4216455 | SO101-2NP | NK14.01.1005 | 1005 | SO101-2NP | 2.11
4265102 | SO101-2NP | NK14.01.1008 | 1008 | SO101-2NP | 2.06
4265463 | SO101-2NP | NK14.01.1010 | 1010 | SO101-2NP | 2.12
4266981 | SO101-2NP | NK14.01.1017 | 1017 | SO101-2NP | 2.20
4267123 | SO101-2NP | NK14.01.1018 | 1018 | SO101-2NP | 2.22
4267263 | SO101-2NP | NK14.01.1020 | 1020 | SO101-2NP | 2.23
4267393 | SO101-2NP | NK14.01.1022 | 1022 | SO101-2NP | 2.24
4267567 | SO101-2NP | NK14.01.1025 | 1025 | SO101-2NP | 2.05

# IfcFurniture: Kancelářský koš:P01_Kancelářský koš (13)
In: SO101-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Neuzavíratelný, ocelový, potažený epoxidovou pryskyřicí odolnou proti poškrábání, objem 15 l; Typ nábytku: Kancelářský koš; Rozměry: 260/315 mm (Ø/v)
Classification: P (Uniformat)
KIC_PSet - Podlaží: SO101-2NP
Name (Kancelářský koš:P01_Kancelářský koš:...) | Kód prvku | Označení | Číslo místnosti
4255095 | NK14.01.1006 | 1006 | 2.04
4255351 | NK14.01.1007 | 1007 | 2.15
4265104 | NK14.01.1009 | 1009 | 2.06
4265465 | NK14.01.1011 | 1011 | 2.12
4265725 | NK14.01.1012 | 1012 | 2.13
4265945 | NK14.01.1013 | 1013 | 2.14
4266169 | NK14.01.1014 | 1014 | 2.15
4266209 | NK14.01.1015 | 1015 | 2.15
4266917 | NK14.01.1016 | 1016 | 2.20
4267244 | NK14.01.1019 | 1019 | 2.22
4267301 | NK14.01.1021 | 1021 | 2.23
4267426 | NK14.01.1023 | 1023 | 2.24
4267513 | NK14.01.1024 | 1024 | 2.05

# IfcFurniture: Konferenční stolek 1x:S13_Konferenční stolek (2)
In: SO101-1NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 13; Konstrukce / Materiály: Deska: bílá HPL deska , tl. desky: 12 mm. Podnoží: 4-ramenný hliníkový kříž, leštěný, plastové kluzáky na koberce, váha: 13 kg; Typ nábytku: Konferenční stolek; Rozměry: 750/450 mm (Ø/v)
KIC_PSet - Podlaží: SO101-1NP; Číslo místnosti: 1.01
Name (Konferenční stolek 1x:S13_Konferenční stolek:...) | Kód prvku | Označení
4167381 | NK11.13.1001 | 1001
4167415 | NK11.13.1002 | 1002

# IfcFurniture: Konferenční stůl:S05_ Konferenční stůl (5)
In: SO101-2NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 05; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, Tl. Desky: 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Konferenční stůl; Rozměry: 1400/800/735-750 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP; Číslo místnosti: 2.16
Name (Konferenční stůl:S05_ Konferenční stůl:...) | Kód prvku | Označení
4204083 | NK03.05.1001 | 1001
4204101 | NK03.05.1002 | 1002
4204113 | NK03.05.1003 | 1003
4204127 | NK03.05.1004 | 1004
4204157 | NK03.05.1009 | 1009

# IfcFurniture: Konferenční stůl:S05_ Konferenční stůl (5)
In: SO101-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 05; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, Tl. Desky: 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Konferenční stůl; Rozměry: 1400/800/735-750 mm (š/h/v)
Classification: S (Uniformat)
KIC_PSet - Podlaží: SO101-2NP; Číslo místnosti: 2.16
Name (Konferenční stůl:S05_ Konferenční stůl:...) | Kód prvku | Označení
4204145 | NK03.05.1005 | 1005
4204146 | NK03.05.1006 | 1006
4204147 | NK03.05.1007 | 1007
4204148 | NK03.05.1008 | 1008
4204189 | NK03.05.1010 | 1010

# IfcFurniture: Konferenční židle stohovatelná:Z02_Konferenční židle stohovatelná (62)
In: SO101-1NP
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: 4-nohá ocelová podnož v povrchové úpravě chrom, trubka - kružnice ø18, plastové kluzáky na koberce černé, hmotnost 6 kg, celočalouněný korpus, tlošťka opěráku 12 mm, tloušťka sedáku 12 mm, materiál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Konferenční židle stohovatelná; Rozměry: 550/570/870 mm (š/h/v); viz nákres
KIC_PSet - Podlaží: SO101-1NP; Číslo místnosti: 1.09
Name (Konferenční židle stohovatelná:Z02_Konferenční židle stohovatelná:...) | Kód prvku | Označení
4159059 | NK02.02.1001 | 1001
4159085 | NK02.02.1002 | 1002
4159097 | NK02.02.1003 | 1003
4159145 | NK02.02.1004 | 1004
4159157 | NK02.02.1005 | 1005
4159175 | NK02.02.1006 | 1006
4159183 | NK02.02.1007 | 1007
4159193 | NK02.02.1008 | 1008
4159203 | NK02.02.1009 | 1009
4159229 | NK02.02.1010 | 1010
4159237 | NK02.02.1011 | 1011
4159247 | NK02.02.1012 | 1012
4159255 | NK02.02.1013 | 1013
4159263 | NK02.02.1014 | 1014
4159271 | NK02.02.1015 | 1015
4159281 | NK02.02.1016 | 1016
4159291 | NK02.02.1017 | 1017
4159299 | NK02.02.1018 | 1018
4159307 | NK02.02.1019 | 1019
4159317 | NK02.02.1020 | 1020
4159325 | NK02.02.1021 | 1021
4159333 | NK02.02.1022 | 1022
4159343 | NK02.02.1023 | 1023
4159353 | NK02.02.1024 | 1024
4159363 | NK02.02.1025 | 1025
4159371 | NK02.02.1026 | 1026
4159381 | NK02.02.1027 | 1027
4159389 | NK02.02.1028 | 1028
4159397 | NK02.02.1029 | 1029
4159405 | NK02.02.1030 | 1030
4159443 | NK02.02.1031 | 1031
4159465 | NK02.02.1032 | 1032
4159477 | NK02.02.1033 | 1033
4159491 | NK02.02.1034 | 1034
4159503 | NK02.02.1035 | 1035
4159511 | NK02.02.1036 | 1036
4159519 | NK02.02.1037 | 1037
4159527 | NK02.02.1038 | 1038
4159557 | NK02.02.1039 | 1039
4159613 | NK02.02.1040 | 1040
4159625 | NK02.02.1041 | 1041
4159635 | NK02.02.1042 | 1042
4159649 | NK02.02.1043 | 1043
4159663 | NK02.02.1044 | 1044
4159675 | NK02.02.1045 | 1045
4159689 | NK02.02.1046 | 1046
4159705 | NK02.02.1047 | 1047
4159731 | NK02.02.1048 | 1048
4159743 | NK02.02.1049 | 1049
4159751 | NK02.02.1050 | 1050
4159763 | NK02.02.1051 | 1051
4159775 | NK02.02.1052 | 1052
4159787 | NK02.02.1053 | 1053
4159797 | NK02.02.1054 | 1054
4159809 | NK02.02.1055 | 1055
4159821 | NK02.02.1056 | 1056
4159881 | NK02.02.1057 | 1057
4159889 | NK02.02.1058 | 1058
4159928 | NK02.02.1059 | 1059
4159952 | NK02.02.1060 | 1060
4159964 | NK02.02.1061 | 1061
4159972 | NK02.02.1062 | 1062

# IfcFurniture: Konferenční židle:Z03A_Konferenční židle (20)
In: SO101-1NP
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03A; Konstrukce / Materiály: 4-ramenný hliníkový kříž, leštěný, kolečka na koberce, černá, Ø 60 mm, hmotnost 8 kg, celočalouněný korpus, tloušťka opěráku 12 mm, tloušťka sedáku 12 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Konferenční židle; Rozměry: 530/580/860 mm (š/h/v); viz nákres
KIC_PSet - Podlaží: SO101-1NP; Číslo místnosti: 1.17
Name (Konferenční židle:Z03A_Konferenční židle:...) | Kód prvku | Označení
4185129 | NK02.03A.1001 | 1001
4185229 | NK02.03A.1002 | 1002
4185241 | NK02.03A.1003 | 1003
4185259 | NK02.03A.1004 | 1004
4185275 | NK02.03A.1005 | 1005
4185287 | NK02.03A.1006 | 1006
4185299 | NK02.03A.1007 | 1007
4185311 | NK02.03A.1008 | 1008
4185349 | NK02.03A.1009 | 1009
4185350 | NK02.03A.1010 | 1010
4185351 | NK02.03A.1011 | 1011
4185352 | NK02.03A.1012 | 1012
4185353 | NK02.03A.1013 | 1013
4185354 | NK02.03A.1014 | 1014
4185355 | NK02.03A.1015 | 1015
4185356 | NK02.03A.1016 | 1016
4185365 | NK02.03A.1017 | 1017
4185396 | NK02.03A.1018 | 1018
4185408 | NK02.03A.1019 | 1019
4185409 | NK02.03A.1020 | 1020

# IfcFurniture: Konferenční židle:Z03B_Konferenční židle (20)
In: SO101-1NP
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03B; Konstrukce / Materiály: 4-ramenný hliníkový kříž, leštěný, kolečka na koberce, černá, Ø 60 mm, hmotnost 8 kg, celočalouněný korpus, tloušťka opěráku 12 mm, tloušťka sedáku 12 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Konferenční židle; Rozměry: 530/580/860 mm (š/h/v); viz nákres
KIC_PSet - Podlaží: SO101-1NP; Číslo místnosti: 1.18
Name (Konferenční židle:Z03B_Konferenční židle:...) | Kód prvku | Označení
4183963 | NK02.03B.1001 | 1001
4184014 | NK02.03B.1002 | 1002
4184026 | NK02.03B.1003 | 1003
4184042 | NK02.03B.1004 | 1004
4184050 | NK02.03B.1005 | 1005
4184066 | NK02.03B.1006 | 1006
4184076 | NK02.03B.1007 | 1007
4184084 | NK02.03B.1008 | 1008
4184094 | NK02.03B.1009 | 1009
4184121 | NK02.03B.1010 | 1010
4184136 | NK02.03B.1011 | 1011
4184137 | NK02.03B.1012 | 1012
4184145 | NK02.03B.1013 | 1013
4184146 | NK02.03B.1014 | 1014
4184147 | NK02.03B.1015 | 1015
4184148 | NK02.03B.1016 | 1016
4184149 | NK02.03B.1017 | 1017
4184150 | NK02.03B.1018 | 1018
4184151 | NK02.03B.1019 | 1019
4184152 | NK02.03B.1020 | 1020

# IfcFurniture: Konferenční židle:Z03_Konferenční židle (32)
In: SO101-2NP
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: 4-ramenný hliníkový kříž, leštěný, kolečka na koberce, černá, Ø 60 mm, hmotnost 8 kg, celočalouněný korpus, tloušťka opěráku 12 mm, tloušťka sedáku 12 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Konferenční židle; Rozměry: 530/580/860 mm (š/h/v); viz nákres
KIC_PSet - Podlaží: SO101-2NP
Name (Konferenční židle:Z03_Konferenční židle:...) | Kód prvku | Označení | Číslo místnosti
4201592 | NK02.03.1001 | 1001 | 2.13
4201644 | NK02.03.1002 | 1002 | 2.13
4201658 | NK02.03.1003 | 1003 | 2.13
4201680 | NK02.03.1004 | 1004 | 2.13
4201681 | NK02.03.1005 | 1005 | 2.13
4201682 | NK02.03.1006 | 1006 | 2.13
4203026 | NK02.03.1007 | 1007 | 2.16
4203034 | NK02.03.1008 | 1008 | 2.16
4203046 | NK02.03.1009 | 1009 | 2.16
4203058 | NK02.03.1010 | 1010 | 2.16
4203068 | NK02.03.1011 | 1011 | 2.16
4203076 | NK02.03.1012 | 1012 | 2.16
4203086 | NK02.03.1013 | 1013 | 2.16
4203096 | NK02.03.1014 | 1014 | 2.16
4203110 | NK02.03.1015 | 1015 | 2.16
4203111 | NK02.03.1016 | 1016 | 2.16
4203112 | NK02.03.1017 | 1017 | 2.16
4203113 | NK02.03.1018 | 1018 | 2.16
4203114 | NK02.03.1019 | 1019 | 2.16
4203115 | NK02.03.1020 | 1020 | 2.16
4203116 | NK02.03.1021 | 1021 | 2.16
4203117 | NK02.03.1022 | 1022 | 2.16
4203146 | NK02.03.1023 | 1023 | 2.16
4203166 | NK02.03.1024 | 1024 | 2.16
4203178 | NK02.03.1025 | 1025 | 2.16
4203179 | NK02.03.1026 | 1026 | 2.16
4265935 | NK02.03.1027 | 1027 | 2.14
4265936 | NK02.03.1028 | 1028 | 2.14
4265937 | NK02.03.1029 | 1029 | 2.14
4265938 | NK02.03.1030 | 1030 | 2.14
4265939 | NK02.03.1031 | 1031 | 2.14
4265940 | NK02.03.1032 | 1032 | 2.14

# IfcFurniture: Koš na WC:P03_Koš na WC (6)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Nerezový nášlapný odpadkový koš s vnitřní plastovou nádobou, černá povrchová úprava, objem 5l; Typ nábytku: Koš na WC; Rozměry: 205/280 mm (Ø/v)
Name (Koš na WC:P03_Koš na WC:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4187472 | SO101-1NP | NK14.03.1001 | 1001 | SO101-1NP | 1.11B
4200352 | SO101-2NP | NK14.03.1002 | 1002 | SO101-2NP | 2.09B
4200424 | SO101-2NP | NK14.03.1003 | 1003 | SO101-2NP | 2.09B
4200433 | SO101-2NP | NK14.03.1004 | 1004 | SO101-2NP | 2.09B
4261908 | SO101-1NP | NK14.03.1005 | 1005 | SO101-1NP | 1.11B
4261917 | SO101-1NP | NK14.03.1006 | 1006 | SO101-1NP | 1.11B

# IfcFurniture: Koš na tříděný odpad:P02_Koš na tříděný odpad (4)
In: SO101-1NP
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Uzavíratelný koš s pedálem vyrobený z polypropyenu, objem 50 l; Typ nábytku: Koš na tříděný odpad; Rozměry: 330/410/625 mm (š/h/v)
KIC_PSet - Podlaží: SO101-1NP
Name (Koš na tříděný odpad:P02_Koš na tříděný odpad:...) | Kód prvku | Označení | Číslo místnosti
4156214 | NK14.02.1001 | 1001 | 1.09
4156245 | NK14.02.1002 | 1002 | 1.09
4156253 | NK14.02.1003 | 1003 | 1.09
4187712 | NK14.02.1012 | 1012 | 1.14

# IfcFurniture: Koš na tříděný odpad:P02_Koš na tříděný odpad (14)
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Uzavíratelný koš s pedálem vyrobený z polypropyenu, objem 50 l; Typ nábytku: Koš na tříděný odpad; Rozměry: 330/410/625 mm (š/h/v)
Classification: P (Uniformat)
Name (Koš na tříděný odpad:P02_Koš na tříděný odpad:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4172324 | SO101-1NP | NK14.02.1004 | 1004 | SO101-1NP | 1.19
4172325 | SO101-1NP | NK14.02.1005 | 1005 | SO101-1NP | 1.19
4181236 | SO101-1NP | NK14.02.1006 | 1006 | SO101-1NP | 1.19
4181298 | SO101-1NP | NK14.02.1007 | 1007 | SO101-1NP | 1.18
4181299 | SO101-1NP | NK14.02.1008 | 1008 | SO101-1NP | 1.18
4181300 | SO101-1NP | NK14.02.1009 | 1009 | SO101-1NP | 1.18
4187652 | SO101-1NP | NK14.02.1010 | 1010 | SO101-1NP | 1.10A
4187696 | SO101-1NP | NK14.02.1011 | 1011 | SO101-1NP | 1.11A
4204740 | SO101-2NP | NK14.02.1013 | 1013 | SO101-2NP | 2.01B
4205874 | SO101-2NP | NK14.02.1014 | 1014 | SO101-2NP | 2.01B
4205897 | SO101-2NP | NK14.02.1015 | 1015 | SO101-2NP | 2.01B
4212365 | SO101-2NP | NK14.02.1016 | 1016 | SO101-2NP | 2.08A
4212404 | SO101-2NP | NK14.02.1017 | 1017 | SO101-2NP | 2.09A
4222094 | SO101-1NP | NK14.02.1018 | 1018 | SO101-1NP | 1.19

# IfcFurniture: Lavice:SN03_Lavice (2)
In: SO101-2NP
Type - Classification: SN Stěny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Dvojmístná lavice, konstrukce z lakovaných dřevěných desek.; Typ nábytku: Lavice; Rozměry: 1200/400/360 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP; Číslo místnosti: 2.01B
Name (Lavice:SN03_Lavice:...) | Kód prvku | Označení
4205766 | NK05.03.1001 | 1001
4205809 | NK05.03.1002 | 1002

# IfcFurniture: Mobilní skladový žebřík:P19_Mobilní skladový žebřík (2)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 19; Konstrukce / Materiály: Stabilní hliníková konstrukce, schůdky hliníkové, lehká Madlo pěnové. konstrukce umožnuje snadnou přepravu a manipulaci. nosnost schůdků je 150 kg, počet schodů -6. Hmotnost 6,1 kg.; Typ nábytku: Mobilní skladový žebřík; Rozměry: složené: 580/60/2020 mm (š/h/v); rozložené: 580/1030/1900 mm (š/h/v); Výška madla: 1900 mm; Pracovní výška: 3 400 mm
Name (Mobilní skladový žebřík:P19_Mobilní skladový žebřík:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4210259 | SO101-1NP | NK21.19.1001 | 1001 | SO101-1NP | 1.16
4210396 | SO101-2NP | NK21.19.1002 | 1002 | SO101-2NP | 2.07

# IfcFurniture: Opěrný stojan:P13_Opěrný stojan (4)
In: SO101-1NP
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 13; Konstrukce / Materiály: Kovová konstrukce s přáškovou barvou; Typ nábytku: Opěrný stojan; Rozměry: 800/50/800 mm (š/h/v)
KIC_PSet - Podlaží: SO101-1NP; Číslo místnosti: 1.01
Name (Opěrný stojan:P13_Opěrný stojan:...) | Kód prvku | Označení
4168257 | NK16.13.1001 | 1001
4168281 | NK16.13.1002 | 1002
4168295 | NK16.13.1003 | 1003
4168303 | NK16.13.1004 | 1004

# IfcFurniture: Otočné křeslo:SN02_Otočné křeslo (6)
Type - Classification: SN Stěny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: 4-ramenný hliníkový kříž, leštěný, plastové kluzáky na koberce, hmotnost 15 kg, celočalouněný korpus, tlošťka opěráku 65 mm, tloušťka sedáku 65 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Otočné křeslo; Rozměry: 760/770/1000 mm (š/h/v); viz nákres
Name (Otočné křeslo:SN02_Otočné křeslo:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4166236 | SO101-1NP | NK04.02.1001 | 1001 | SO101-1NP | 1.01
4166415 | SO101-1NP | NK04.02.1002 | 1002 | SO101-1NP | 1.01
4166436 | SO101-1NP | NK04.02.1003 | 1003 | SO101-1NP | 1.01
4166437 | SO101-1NP | NK04.02.1004 | 1004 | SO101-1NP | 1.01
4227107 | SO101-2NP | NK04.02.1005 | 1005 | SO101-2NP | 2.01B
4227108 | SO101-2NP | NK04.02.1006 | 1006 | SO101-2NP | 2.01B

# IfcFurniture: Piktogramy:Cedule s piktogramem - WC imobilní (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 05; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem -WC imobilní; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - WC imobilní:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4363966 | SO101-1NP | NK25.05.1001 | 1001 | SO101-1NP | 1.14
4369667 | SO101-2NP | NK25.05.1002 | 1002 | SO101-2NP | 2.11

# IfcFurniture: Piktogramy:Cedule s piktogramem - WC muži (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem WC muži; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - WC muži:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4365244 | SO101-1NP | NK25.04.1001 | 1001 | SO101-1NP | 1.10A
4369621 | SO101-2NP | NK25.04.1002 | 1002 | SO101-2NP | 2.08A

# IfcFurniture: Piktogramy:Cedule s piktogramem - WC ženy (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem - WC ženy; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - WC ženy:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4365226 | SO101-1NP | NK25.03.1001 | 1001 | SO101-1NP | 1.11A
4369519 | SO101-2NP | NK25.03.1002 | 1002 | SO101-2NP | 2.09A

# IfcFurniture: Piktogramy:Cedule s piktogramem - přebalovací pult (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 06; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem -přebalovací pult; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - přebalovací pult:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4375014 | SO101-1NP | NK25.06.1001 | 1001 | SO101-1NP | 1.14
4375113 | SO101-2NP | NK25.06.1002 | 1002 | SO101-2NP | 2.11

# IfcFurniture: Piktogramy:Cedule s piktogramem - sprcha muži (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 08; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem -sprcha muži; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - sprcha muži:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4365173 | SO101-1NP | NK25.08.1001 | 1001 | SO101-1NP | 1.12
4369743 | SO101-2NP | NK25.08.1002 | 1002 | SO101-2NP | 2.19

# IfcFurniture: Piktogramy:Cedule s piktogramem - sprcha ženy (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 07; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem -sprcha ženy; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - sprcha ženy:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4365085 | SO101-1NP | NK25.07.1001 | 1001 | SO101-1NP | 1.13
4369698 | SO101-2NP | NK25.07.1002 | 1002 | SO101-2NP | 2.17

# IfcFurniture: Pracovní stůl:S01_Pracovní stůl (10)
In: SO101-2NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Pracovní stůl; Rozměry: 1800/800/735 -750 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP
Name (Pracovní stůl:S01_Pracovní stůl:...) | Kód prvku | Označení | Číslo místnosti
4152155 | NK03.01.1001 | 1001 | 2.04
4197877 | NK03.01.1003 | 1003 | 2.06
4204432 | NK03.01.1005 | 1005 | 2.15
4227603 | NK03.01.1006 | 1006 | 2.15
4265459 | NK03.01.1007 | 1007 | 2.12
4266979 | NK03.01.1014 | 1014 | 2.20
4267085 | NK03.01.1015 | 1015 | 2.22
4267260 | NK03.01.1017 | 1017 | 2.23
4267390 | NK03.01.1019 | 1019 | 2.24
4267559 | NK03.01.1022 | 1022 | 2.05

# IfcFurniture: Pracovní stůl:S01_Pracovní stůl (12)
In: SO101-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Pracovní stůl; Rozměry: 1800/800/735 -750 mm (š/h/v)
Classification: S (Uniformat)
KIC_PSet - Podlaží: SO101-2NP
Name (Pracovní stůl:S01_Pracovní stůl:...) | Kód prvku | Označení | Číslo místnosti
4197583 | NK03.01.1002 | 1002 | 2.04
4197878 | NK03.01.1004 | 1004 | 2.06
4265460 | NK03.01.1008 | 1008 | 2.12
4265720 | NK03.01.1009 | 1009 | 2.13
4265942 | NK03.01.1010 | 1010 | 2.14
4266167 | NK03.01.1011 | 1011 | 2.15
4266207 | NK03.01.1012 | 1012 | 2.15
4266915 | NK03.01.1013 | 1013 | 2.20
4267229 | NK03.01.1016 | 1016 | 2.22
4267298 | NK03.01.1018 | 1018 | 2.23
4267423 | NK03.01.1020 | 1020 | 2.24
4267511 | NK03.01.1021 | 1021 | 2.05

# IfcFurniture: Pracovní stůl:S02_Pracovní stůl (18)
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Pracovní stůl; Rozměry: 1600/800/735-750 mm (š/h/v)
Name (Pracovní stůl:S02_Pracovní stůl:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4152188 | SO101-1NP | NK03.02.1001 | 1001 | SO101-1NP | 1.09
4152224 | SO101-1NP | NK03.02.1002 | 1002 | SO101-1NP | 1.09
4152339 | SO101-1NP | NK03.02.1003 | 1003 | SO101-1NP | 1.09
4152361 | SO101-1NP | NK03.02.1004 | 1004 | SO101-1NP | 1.09
4152462 | SO101-1NP | NK03.02.1006 | 1006 | SO101-1NP | 1.09
4152498 | SO101-1NP | NK03.02.1007 | 1007 | SO101-1NP | 1.09
4152510 | SO101-1NP | NK03.02.1008 | 1008 | SO101-1NP | 1.09
4152693 | SO101-1NP | NK03.02.1012 | 1012 | SO101-1NP | 1.09
4152707 | SO101-1NP | NK03.02.1013 | 1013 | SO101-1NP | 1.09
4152726 | SO101-1NP | NK03.02.1014 | 1014 | SO101-1NP | 1.09
4197597 | SO101-2NP | NK03.02.1015 | 1015 | SO101-2NP | 2.04
4197857 | SO101-2NP | NK03.02.1016 | 1016 | SO101-2NP | 2.05
4197879 | SO101-2NP | NK03.02.1017 | 1017 | SO101-2NP | 2.06
4265461 | SO101-2NP | NK03.02.1020 | 1020 | SO101-2NP | 2.12
4265721 | SO101-2NP | NK03.02.1021 | 1021 | SO101-2NP | 2.13
4265787 | SO101-2NP | NK03.02.1022 | 1022 | SO101-2NP | 2.13
4265943 | SO101-2NP | NK03.02.1023 | 1023 | SO101-2NP | 2.14
4265952 | SO101-2NP | NK03.02.1024 | 1024 | SO101-2NP | 2.14

# IfcFurniture: Pracovní stůl:S02_Pracovní stůl (7)
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Pracovní stůl; Rozměry: 1600/800/735-750 mm (š/h/v)
Classification: S (Uniformat)
Name (Pracovní stůl:S02_Pracovní stůl:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4152442 | SO101-1NP | NK03.02.1005 | 1005 | SO101-1NP | 1.09
4152643 | SO101-1NP | NK03.02.1009 | 1009 | SO101-1NP | 1.09
4152661 | SO101-1NP | NK03.02.1010 | 1010 | SO101-1NP | 1.09
4152679 | SO101-1NP | NK03.02.1011 | 1011 | SO101-1NP | 1.09
4208488 | SO101-2NP | NK03.02.1018 | 1018 | SO101-2NP | 2.23
4208683 | SO101-2NP | NK03.02.1019 | 1019 | SO101-2NP | 2.24
4346343 | SO101-1NP | NK03.02.1025 | 1025 | SO101-1NP | 1.09

# IfcFurniture: Přídavna deska stolu:S04_Přídavna deska stolu (2)
In: SO101-2NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem tl. 25 mm a hranami ABS tl. 2 mm; Typ nábytku: Přídavná deska stolu; Rozměry: 800/600 mm (š/h)
KIC_PSet - Podlaží: SO101-2NP
Name (Přídavna deska stolu:S04_Přídavna deska stolu:...) | Kód prvku | Označení | Číslo místnosti
4202636 | NK03.04.1001 | 1001 | 2.13
4265941 | NK03.04.1002 | 1002 | 2.14

# IfcFurniture: Recepční stůl:S15_Recepční stůl, Recepční stůl:S15_Recepční stůl:4169411
In: SO101-1NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 15; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník, krycí desky stolu s nástavcem - dřevotřískové desky s melaminovým potahem a hranami ABS tl. 2 mm, tl. desek: 20 mm; Typ nábytku: Recepční stůl; Rozměry: 2650/1440/950 mm (š/h/v)
KIC_PSet - Kód prvku: NK03.15.1001; Označení: 1001; Podlaží: SO101-1NP; Číslo místnosti: 1.03

# IfcFurniture: Regál na šanony:SK06_Regál na šanony (20)
In: SO101-2NP
Type - Classification: SK Střešní krytiny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 06; Konstrukce / Materiály: pevné šroubované policové regály FIX, nosnost regálů sle statického posudku, kovová konstrukce, nastavitelná výška polic; Typ nábytku: Regál na šanony; Rozměry: 900/400/2650 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP
Name (Regál na šanony:SK06_Regál na šanony:...) | Kód prvku | Označení | Číslo místnosti
4273740 | NK10.06.1001 | 1001 | 2.07
4278313 | NK10.06.1002 | 1002 | 2.07
4278323 | NK10.06.1003 | 1003 | 2.07
4278331 | NK10.06.1004 | 1004 | 2.07
4278341 | NK10.06.1005 | 1005 | 2.07
4278588 | NK10.06.1006 | 1006 | 2.07
4278614 | NK10.06.1007 | 1007 | 2.07
4278622 | NK10.06.1008 | 1008 | 2.07
4278632 | NK10.06.1009 | 1009 | 2.07
4278642 | NK10.06.1010 | 1010 | 2.07
4278654 | NK10.06.1011 | 1011 | 2.07
4278678 | NK10.06.1012 | 1012 | 2.21
4278688 | NK10.06.1013 | 1013 | 2.21
4278728 | NK10.06.1014 | 1014 | 2.21
4278729 | NK10.06.1015 | 1015 | 2.21
4278741 | NK10.06.1016 | 1016 | 2.21
4278742 | NK10.06.1017 | 1017 | 2.21
4278758 | NK10.06.1018 | 1018 | 2.21
4278759 | NK10.06.1019 | 1019 | 2.21
4283728 | NK10.06.1020 | 1020 | 2.21

# IfcFurniture: Rudl na přepravu konferenčních židlí:P18_Rudl na přepravu konferenčních židlí, Rudl na přepravu konferenčních židlí:P18_Rudl na přepravu konferenčních židlí:4212254
In: SO101-1NP
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 18; Konstrukce / Materiály: Konstrukce z ocelových trubek opatřených práškovou barvou. Kola plná, průměr 200 mm, hmostnost 8 kg, nosnost celkem 150 kg.; Typ nábytku: Rudl na přepravu konferenčních žídlí; Rozměry: Lopata: 275/475 (š/h)
KIC_PSet - Kód prvku: NK20.18.1001; Označení: 1001; Podlaží: SO101-1NP; Číslo místnosti: 1.16

# IfcFurniture: Sedačka:SN01A_Sedačka, Sedačka:SN01A_Sedačka:4176515
In: SO101-1NP
Type - Classification: SN Stěny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01A; Konstrukce / Materiály: Dvojmístné křeslo, 4-nohá dřevěná podnož ze světlého masivního dřeva, bez kluzáků, hmotnost 24 kg, celočalouněný korpus. Tloušťka opěráku 30 mm, tloušťka sedáku 35 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Sedačka; Rozměry: 1320/760/760 mm (š/h/v); viz nákres
KIC_PSet - Kód prvku: NK07.01A.1001; Označení: 1001; Podlaží: SO101-1NP; Číslo místnosti: 1.19

# IfcFurniture: Sedačka:SN01C_Sedačka, Sedačka:SN01C_Sedačka:4205842
In: SO101-2NP
Type - Classification: SN Stěny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01C; Konstrukce / Materiály: Dvojmístné křeslo, 4-nohá dřevěná podnož ze světlého masivního dřeva, bez kluzáků, hmotnost 24 kg, celočalouněný korpus. Tloušťka opěráku 30 mm, tloušťka sedáku 35 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Sedačka; Rozměry: 1320/760/760 mm (š/h/v); viz nákres
KIC_PSet - Kód prvku: NK07.01C.1001; Označení: 1001; Podlaží: SO101-2NP; Číslo místnosti: 2.01B

# IfcFurniture: Sklápěcí stůl:S12_Sklápěcí stůl, Sklápěcí stůl:S12_Sklápěcí stůl:4215873
In: SO101-2NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 12; Konstrukce / Materiály: Deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Podnoží z masivního dřeva světlé barvy; Typ nábytku: Sklápěcí stůl; Rozměry: 800/400/600 mm (š/h/v)
KIC_PSet - Kód prvku: NK11.12.1001; Označení: 1001; Podlaží: SO101-2NP; Číslo místnosti: 2.01C

# IfcFurniture: Skříň kancelářská vysoká:SK02_Skříň kancelářská vysoká (5)
In: SO101-2NP
Type - Classification: SK Střešní krytiny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm; Typ nábytku: Skříň kancelářská vysoká; Rozměry: 800/470/2100 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP
Name (Skříň kancelářská vysoká:SK02_Skříň kancelářská vysoká:...) | Kód prvku | Označení | Číslo místnosti
4202714 | NK10.02.1001 | 1001 | 2.12
4207974 | NK10.02.1002 | 1002 | 2.20
4208012 | NK10.02.1003 | 1003 | 2.20
4267184 | NK10.02.1008 | 1008 | 2.22
4267185 | NK10.02.1009 | 1009 | 2.22

# IfcFurniture: Skříň kancelářská vysoká:SK02_Skříň kancelářská vysoká (4)
In: SO101-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm; Typ nábytku: Skříň kancelářská vysoká; Rozměry: 800/470/2100 mm (š/h/v)
Classification: SK Střešní krytiny (Uniformat)
KIC_PSet - Podlaží: SO101-2NP
Name (Skříň kancelářská vysoká:SK02_Skříň kancelářská vysoká:...) | Kód prvku | Označení | Číslo místnosti
4208028 | NK10.02.1004 | 1004 | 2.20
4208029 | NK10.02.1005 | 1005 | 2.20
4267081 | NK10.02.1006 | 1006 | 2.22
4267082 | NK10.02.1007 | 1007 | 2.22

# IfcFurniture: Skříň kancelářská vysoká:SK03_Skříň kancelářská vysoká (29)
Type - Classification: SK Střešní krytiny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm; Typ nábytku: Skříň kancelářská vysoká; Rozměry: 1000/470/2100 mm (š/h/v)
Name (Skříň kancelářská vysoká:SK03_Skříň kancelářská vysoká:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4172163 | SO101-1NP | NK10.03.1001 | 1001 | SO101-1NP | 1.03
4197978 | SO101-2NP | NK10.03.1004 | 1004 | SO101-2NP | 2.04
4197998 | SO101-2NP | NK10.03.1005 | 1005 | SO101-2NP | 2.04
4199067 | SO101-2NP | NK10.03.1010 | 1010 | SO101-2NP | 2.06
4199068 | SO101-2NP | NK10.03.1011 | 1011 | SO101-2NP | 2.06
4201164 | SO101-2NP | NK10.03.1014 | 1014 | SO101-2NP | 2.12
4201176 | SO101-2NP | NK10.03.1015 | 1015 | SO101-2NP | 2.12
4201198 | SO101-2NP | NK10.03.1016 | 1016 | SO101-2NP | 2.12
4201199 | SO101-2NP | NK10.03.1017 | 1017 | SO101-2NP | 2.12
4201225 | SO101-2NP | NK10.03.1018 | 1018 | SO101-2NP | 2.13
4201226 | SO101-2NP | NK10.03.1019 | 1019 | SO101-2NP | 2.13
4201252 | SO101-2NP | NK10.03.1020 | 1020 | SO101-2NP | 2.13
4201253 | SO101-2NP | NK10.03.1021 | 1021 | SO101-2NP | 2.13
4201264 | SO101-2NP | NK10.03.1022 | 1022 | SO101-2NP | 2.13
4202739 | SO101-2NP | NK10.03.1029 | 1029 | SO101-2NP | 2.15
4202990 | SO101-2NP | NK10.03.1032 | 1032 | SO101-2NP | 2.16
4202991 | SO101-2NP | NK10.03.1033 | 1033 | SO101-2NP | 2.16
4202992 | SO101-2NP | NK10.03.1034 | 1034 | SO101-2NP | 2.16
4202993 | SO101-2NP | NK10.03.1035 | 1035 | SO101-2NP | 2.16
4202994 | SO101-2NP | NK10.03.1036 | 1036 | SO101-2NP | 2.16
4208514 | SO101-2NP | NK10.03.1037 | 1037 | SO101-2NP | 2.23
4208544 | SO101-2NP | NK10.03.1038 | 1038 | SO101-2NP | 2.23
4208630 | SO101-2NP | NK10.03.1040 | 1040 | SO101-2NP | 2.24
4208631 | SO101-2NP | NK10.03.1041 | 1041 | SO101-2NP | 2.24
4227573 | SO101-2NP | NK10.03.1044 | 1044 | SO101-2NP | 2.15
4227583 | SO101-2NP | NK10.03.1045 | 1045 | SO101-2NP | 2.15
4227591 | SO101-2NP | NK10.03.1046 | 1046 | SO101-2NP | 2.15
4267627 | SO101-2NP | NK10.03.1050 | 1050 | SO101-2NP | 2.05
4267650 | SO101-2NP | NK10.03.1051 | 1051 | SO101-2NP | 2.05

# IfcFurniture: Skříň kancelářská vysoká:SK03_Skříň kancelářská vysoká (22)
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm; Typ nábytku: Skříň kancelářská vysoká; Rozměry: 1000/470/2100 mm (š/h/v)
Classification: SK Střešní krytiny (Uniformat)
Name (Skříň kancelářská vysoká:SK03_Skříň kancelářská vysoká:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4185488 | SO101-1NP | NK10.03.1002 | 1002 | SO101-1NP | 1.16
4185505 | SO101-1NP | NK10.03.1003 | 1003 | SO101-1NP | 1.16
4198020 | SO101-2NP | NK10.03.1006 | 1006 | SO101-2NP | 2.04
4198028 | SO101-2NP | NK10.03.1007 | 1007 | SO101-2NP | 2.04
4198974 | SO101-2NP | NK10.03.1008 | 1008 | SO101-2NP | 2.05
4198975 | SO101-2NP | NK10.03.1009 | 1009 | SO101-2NP | 2.05
4199091 | SO101-2NP | NK10.03.1012 | 1012 | SO101-2NP | 2.06
4199092 | SO101-2NP | NK10.03.1013 | 1013 | SO101-2NP | 2.06
4201288 | SO101-2NP | NK10.03.1023 | 1023 | SO101-2NP | 2.13
4201328 | SO101-2NP | NK10.03.1024 | 1024 | SO101-2NP | 2.14
4201329 | SO101-2NP | NK10.03.1025 | 1025 | SO101-2NP | 2.14
4201351 | SO101-2NP | NK10.03.1026 | 1026 | SO101-2NP | 2.14
4201352 | SO101-2NP | NK10.03.1027 | 1027 | SO101-2NP | 2.14
4201361 | SO101-2NP | NK10.03.1028 | 1028 | SO101-2NP | 2.14
4202779 | SO101-2NP | NK10.03.1030 | 1030 | SO101-2NP | 2.15
4202781 | SO101-2NP | NK10.03.1031 | 1031 | SO101-2NP | 2.15
4208564 | SO101-2NP | NK10.03.1039 | 1039 | SO101-2NP
4208650 | SO101-2NP | NK10.03.1042 | 1042 | SO101-2NP | 2.24
4208651 | SO101-2NP | NK10.03.1043 | 1043 | SO101-2NP | 2.24
4227776 | SO101-1NP | NK10.03.1047 | 1047 | SO101-1NP | 1.04
4266061 | SO101-2NP | NK10.03.1048 | 1048 | SO101-2NP | 2.14
4267362 | SO101-2NP | NK10.03.1049 | 1049 | SO101-2NP | 2.23

# IfcFurniture: Skříň šatní vysoká SK04:SK04_Skříň šatní vysoká, Skříň šatní vysoká SK04:SK04_Skříň šatní vysoká:4160925
In: SO101-1NP
Type - Classification: SK Střešní krytiny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Členění 2 x 1000 mm; Typ nábytku: Skříň šatní vysoká; Rozměry: 2000/580/2360 mm (š/h/v)
KIC_PSet - Kód prvku: NK10.04.1001; Označení: 1001; Podlaží: SO101-1NP; Číslo místnosti: 1.09

# IfcFurniture: Skříň šatní vysoká SK05:SK05_Skříň šatní vysoká, Skříň šatní vysoká SK05:SK05_Skříň šatní vysoká:4185117
In: SO101-1NP
Type - Classification: SK Střešní krytiny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 05; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Členění 1 x 750 + 1 x 500 mm; Typ nábytku: Skříň šatní vysoká; Rozměry: 1250/580/2360 mm (š/h/v)
KIC_PSet - Kód prvku: NK10.05.1001; Označení: 1001; Podlaží: SO101-1NP; Číslo místnosti: 1.17

# IfcFurniture: Skříň šatní:SK01_Skříň šatní (17)
In: SO101-2NP
Type - Classification: SK Střešní krytiny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm; Typ nábytku: Skříň šatní; Rozměry: 600/470/2100 mm (š/h/v)
KIC_PSet - Podlaží: SO101-2NP
Name (Skříň šatní:SK01_Skříň šatní:...) | Kód prvku | Označení | Číslo místnosti
4198894 | NK10.01.1001 | 1001 | 2.04
4198920 | NK10.01.1002 | 1002 | 2.04
4198976 | NK10.01.1003 | 1003 | 2.05
4198993 | NK10.01.1004 | 1004 | 2.05
4199069 | NK10.01.1005 | 1005 | 2.06
4199093 | NK10.01.1006 | 1006 | 2.06
4201435 | NK10.01.1007 | 1007 | 2.12
4201459 | NK10.01.1008 | 1008 | 2.12
4201548 | NK10.01.1009 | 1009 | 2.13
4202799 | NK10.01.1010 | 1010 | 2.15
4202830 | NK10.01.1011 | 1011 | 2.15
4202842 | NK10.01.1012 | 1012 | 2.15
4208592 | NK10.01.1013 | 1013 | 2.23
4208632 | NK10.01.1014 | 1014 | 2.24
4266012 | NK10.01.1015 | 1015 | 2.14
4267363 | NK10.01.1016 | 1016 | 2.23
4267472 | NK10.01.1017 | 1017 | 2.24

# IfcFurniture: Sprchová stolička:P15_Sprchová stolička (4)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 15; Konstrukce / Materiály: Konstrukce z plastu - akrylátu s otvory pro manipulaci, nosnost 130 kg; Typ nábytku: Sprchová stolička; Rozměry: 330/275/480 mm (š/h/v)
Name (Sprchová stolička:P15_Sprchová stolička:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4197452 | SO101-1NP | NK18.15.1001 | 1001 | SO101-1NP | 1.12
4197482 | SO101-1NP | NK18.15.1002 | 1002 | SO101-1NP | 1.13
4216120 | SO101-2NP | NK18.15.1003 | 1003 | SO101-2NP | 2.17
4216157 | SO101-2NP | NK18.15.1004 | 1004 | SO101-2NP | 2.19

# IfcFurniture: Stojan na deštníky:P12_Stojan na deštníky (3)
In: SO101-1NP
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 12; Konstrukce / Materiály: Nerezová nádoba z černé práškově lakované oceli; Typ nábytku: Stojan na deštníky; Rozměry: 250/490 mm (Ø/v)
KIC_PSet - Podlaží: SO101-1NP
Name (Stojan na deštníky:P12_Stojan na deštníky:...) | Kód prvku | Označení | Číslo místnosti
4157086 | NK15.12.1001 | 1001 | 1.09
4165303 | NK15.12.1002 | 1002 | 1.01
4181332 | NK15.12.1003 | 1003 | 1.18

# IfcFurniture: Stůl exteriérový:EN02_Stůl exteriérový (3)
In: SO101-2NP
Type - Classification: EN (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Konstrukce ocelová pozinkovaná a ošetřená barvou v laku. Podnož tříramenná. Hmotnost: 6,3 kg. Vhodný pro venkovní použití.; Typ nábytku: Stůl exteriérový; Rozměry: 600/720 mm (Ø/v)
KIC_PSet - Podlaží: SO101-2NP; Číslo místnosti: 2.25
Name (Stůl exteriérový:EN02_Stůl exteriérový:...) | Kód prvku | Označení
4222650 | NK11.02.1001 | 1001
4222661 | NK11.02.1002 | 1002
4222662 | NK11.02.1003 | 1003

# IfcFurniture: Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1 (10)
Type - Classification: KK (Uniformat); Material: <Unnamed>, Plast černý
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm, Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm. Vysunutí zásuvky max. na 75% hloubky. Kontejner je opatřen zámkovým systémem, který centrálně uzavírá a otevírá všechny zásuvky kontejneru a současně blokuje výsuv více než jedné zásuvky.; Typ nábytku: Uzamykatelný mobilní kontejner 3+1; Rozměry: 443/600/602 mm (š/h/v)
Name (Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4171256 | SO101-1NP | NK13.01.1001 | 1001 | SO101-1NP | 1.03
4197753 | SO101-2NP | NK13.01.1002 | 1002 | SO101-2NP | 2.04
4265103 | SO101-2NP | NK13.01.1004 | 1004 | SO101-2NP | 2.06
4265464 | SO101-2NP | NK13.01.1006 | 1006 | SO101-2NP | 2.12
4266283 | SO101-2NP | NK13.01.1012 | 1012 | SO101-2NP | 2.15
4266982 | SO101-2NP | NK13.01.1014 | 1014 | SO101-2NP | 2.20
4267124 | SO101-2NP | NK13.01.1015 | 1015 | SO101-2NP | 2.22
4267264 | SO101-2NP | NK13.01.1017 | 1017 | SO101-2NP | 2.23
4267394 | SO101-2NP | NK13.01.1019 | 1019 | SO101-2NP | 2.24
4267568 | SO101-2NP | NK13.01.1022 | 1022 | SO101-2NP | 2.05

# IfcFurniture: Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1 (12)
In: SO101-2NP
Type - Material: <Unnamed>, Plast černý
