Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: 220052
Time: 2023-05-18T10:03:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.5.0.0 - Alternate UI 22.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 18 10:03:50 2023 * Host: EBC-74 * Database: C:\Users\VIT~1.VEV\AppData\Local\Temp\dc923746-f19b-479a-b016-3a60ca5012d0\790e9173-3fa9-4453-a806-f9e31f506c08\ifc * Database version: 5507 * Database creation date: Thu May 18 10:03:46 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu May 18 10:03:47 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 18 10:03:47 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 220052
LongName: KARLOVARSKÉ INOVAČNÍ CENTRUM; Phase: DPS

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Podlaží:Podlaží (2)
Name | LongName | Elevation (mm)
SO102-1NP | SO102-1NP | 0
SO102-2NP | SO102-2NP | 4200

# IfcFurniture: Barová židle:Z05A_ Barová židle (6)
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 05A; Konstrukce / Materiály: 4-nohá dřevěná podnož z masivního dřeva, bez kluzáků, dřevěný korpus překližka, barevný lak, hmotnost 5,2 kg; Typ nábytku: Barová židle; Rozměry: Celkové: 490/479/994 mm (š/h/v); Sedadlo: 440/360/780 mm (š/h/v)
Name (Barová židle:Z05A_ Barová židle:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4161106 | SO102-1NP | NK12.05A.2001 | 2001 | SO102-1NP | 1.02B
4163023 | SO102-1NP | NK12.05A.2002 | 2002 | SO102-1NP | 1.02B
4163033 | SO102-1NP | NK12.05A.2003 | 2003 | SO102-1NP | 1.02B
4194853 | SO102-2NP | NK12.05A.2004 | 2004 | SO102-2NP | 2.01B
4194854 | SO102-2NP | NK12.05A.2005 | 2005 | SO102-2NP | 2.01B
4194855 | SO102-2NP | NK12.05A.2006 | 2006 | SO102-2NP | 2.01B

# IfcFurniture: Barový stůl exteriérový:EN01_Barový stůl exteriérový (3)
In: SO102-2NP
Type - Classification: EN (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Konstrukce čtřnohé podnože - ocelová pozinkovaná a ošetřená barvou v laku. Vysoce odolná kompaktní HPL deska odolná proti vlhkosti. Hmotnost: 18 kg. Vhodný pro venkovní použití.; Typ nábytku: Barový stůl; Rozměry: 1200/500/1100 mm (š/h/v)
KIC_PSet - Podlaží: SO102-2NP; Číslo místnosti: 2.29
Name (Barový stůl exteriérový:EN01_Barový stůl exteriérový:...) | Kód prvku | Označení
4196913 | NK11.01.2001 | 2001
4204074 | NK11.01.2002 | 2002
4204084 | NK11.01.2003 | 2003

# IfcFurniture: Barový stůl:S10_Barový stůl (2)
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 10; Konstrukce / Materiály: Deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Podnoží z masivního dřeva světlé barvy; Typ nábytku: Barový stůl; Rozměry: 1800/600/1100 mm (š/h/v)
Name (Barový stůl:S10_Barový stůl:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4161105 | SO102-1NP | NK11.10.2001 | 2001 | SO102-1NP | 1.02B
4194852 | SO102-2NP | NK11.10.2002 | 2002 | SO102-2NP | 2.01B

# IfcFurniture: DVERE-Tabule:informační tabulka (37)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Tabulka se skládá z profilu ze stříbrně eloxovaného hliníku, který je zakončen plastovými bočnicemi šedé barvy. Části se do sebe jednoduše zaklapují. Do profilu se vkládá papírový výtisk chráněný krycím antireflexním plastem nebo gravírovaný pásek z umělé hmoty anebo kovový pásek s natištěnými informacemi. Tabulku je možno dle podkladu přišroubovat nebo přilepit pomocí oboustranné lepenky. V plastových bočnicích jsou otvory pro přišroubování.; Typ nábytku: Informační tabulka; Rozměry: 187/62 mm (š/v)
Name (DVERE-Tabule:informační tabulka:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4325929 | SO102-1NP | NK25.02.2001 | 2001 | SO102-1NP | 1.06
4326025 | SO102-1NP | NK25.02.2002 | 2002 | SO102-1NP | 1.06
4326045 | SO102-1NP | NK25.02.2003 | 2003 | SO102-1NP | 1.05
4326057 | SO102-1NP | NK25.02.2004 | 2004 | SO102-1NP | 1.05
4326071 | SO102-1NP | NK25.02.2005 | 2005 | SO102-1NP | 1.23
4326105 | SO102-1NP | NK25.02.2006 | 2006 | SO102-1NP | 1.23
4326115 | SO102-1NP | NK25.02.2007 | 2007 | SO102-1NP | 1.22
4326125 | SO102-1NP | NK25.02.2008 | 2008 | SO102-1NP | 1.22
4326256 | SO102-1NP | NK25.02.2009 | 2009 | SO102-1NP | 1.10
4326309 | SO102-1NP | NK25.02.2010 | 2010 | SO102-1NP | 1.13
4326325 | SO102-1NP | NK25.02.2011 | 2011 | SO102-1NP | 1.13
4326337 | SO102-1NP | NK25.02.2012 | 2012 | SO102-1NP | 1.12
4326349 | SO102-1NP | NK25.02.2013 | 2013 | SO102-1NP | 1.12
4326365 | SO102-1NP | NK25.02.2014 | 2014 | SO102-1NP | 1.11
4326379 | SO102-1NP | NK25.02.2015 | 2015 | SO102-1NP | 1.11
4326395 | SO102-1NP | NK25.02.2016 | 2016 | SO102-1NP | 1.11
4326520 | SO102-1NP | NK25.02.2017 | 2017 | SO102-1NP | 1.15
4326571 | SO102-1NP | NK25.02.2018 | 2018 | SO102-1NP | 1.14
4326828 | SO102-2NP | NK25.02.2019 | 2019 | SO102-2NP | 2.06
4326882 | SO102-2NP | NK25.02.2020 | 2020 | SO102-2NP | 2.05
4326896 | SO102-2NP | NK25.02.2021 | 2021 | SO102-2NP | 2.05
4326908 | SO102-2NP | NK25.02.2022 | 2022 | SO102-2NP | 2.04
4326984 | SO102-2NP | NK25.02.2023 | 2023 | SO102-2NP | 2.27
4327020 | SO102-2NP | NK25.02.2024 | 2024 | SO102-2NP | 2.26
4327028 | SO102-2NP | NK25.02.2025 | 2025 | SO102-2NP | 2.25
4327042 | SO102-2NP | NK25.02.2026 | 2026 | SO102-2NP | 2.24
4327054 | SO102-2NP | NK25.02.2027 | 2027 | SO102-2NP | 2.23
4327066 | SO102-2NP | NK25.02.2028 | 2028 | SO102-2NP | 2.22
4327139 | SO102-2NP | NK25.02.2029 | 2029 | SO102-2NP | 2.17
4327193 | SO102-2NP | NK25.02.2030 | 2030 | SO102-2NP | 2.16
4327203 | SO102-2NP | NK25.02.2031 | 2031 | SO102-2NP | 2.15
4327213 | SO102-2NP | NK25.02.2032 | 2032 | SO102-2NP | 2.14
4327225 | SO102-2NP | NK25.02.2033 | 2033 | SO102-2NP | 2.13
4327333 | SO102-2NP | NK25.02.2034 | 2034 | SO102-2NP | 2.09
4327388 | SO102-2NP | NK25.02.2035 | 2035 | SO102-2NP | 2.10
4327406 | SO102-2NP | NK25.02.2036 | 2036 | SO102-2NP | 2.11
4327422 | SO102-2NP | NK25.02.2037 | 2037 | SO102-2NP | 2.12

# IfcFurniture: INFO-Tabule:Hlavní orientační tabule (2)
In: SO102-1NP
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Tabule ze stříbrně eloxovaného hliníkového systému. Jednotlivé profily jsou do sebe zacvaknuty. Hliníkové bočnice jsou ze stejného materiálu i stejné barvy. Na horním i dolním konci obou bočnic jsou přišroubovány černé plastové krytky. Celá hlavní orientační tabule je nalepena na nosné plastové desce, v které jsou vyvrtány otvory pro montáž celého panelu na zeď. Informační text je řešen polepením fóliovou grafikou dle požadavků.; Typ nábytku: Hlavní orientační tabule; Rozměry: 1218/656 mm (š/v)
KIC_PSet - Podlaží: SO102-1NP
Name (INFO-Tabule:Hlavní orientační tabule:...) | Kód prvku | Označení | Číslo místnosti
4327510 | NK25.01.2001 | 2001 | 1.01
4328443 | NK25.01.2002 | 2002 | 1.03

# IfcFurniture: Jídelní stůl kulatý:S07_Jídelní stůl (7)
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 07; Konstrukce / Materiály: Deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Podnoží z masivního dřeva světlé barvy 4 nohy.; Typ nábytku: Jídelní stůl; Rozměry: 900/750 mm (Ø/v)
Name (Jídelní stůl kulatý:S07_Jídelní stůl:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4167189 | SO102-1NP | NK11.07.2001 | 2001 | SO102-1NP | 1.02C
4168141 | SO102-1NP | NK11.07.2002 | 2002 | SO102-1NP | 1.02C
4168151 | SO102-1NP | NK11.07.2003 | 2003 | SO102-1NP | 1.02C
4194953 | SO102-2NP | NK11.07.2004 | 2004 | SO102-2NP | 2.01C
4194954 | SO102-2NP | NK11.07.2005 | 2005 | SO102-2NP | 2.01C
4194955 | SO102-2NP | NK11.07.2006 | 2006 | SO102-2NP | 2.01C
4194996 | SO102-2NP | NK11.07.2007 | 2007 | SO102-2NP | 2.01B

# IfcFurniture: Jídelní stůl:S08_Jídelní stůl (2)
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 08; Konstrukce / Materiály: Deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Podnoží z masivního dřeva světlé barvy; Typ nábytku: Jídelní stůl; Rozměry: 2000/800/750 mm (š/h/v)
Name (Jídelní stůl:S08_Jídelní stůl:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4155416 | SO102-1NP | NK11.08.2001 | 2001 | SO102-1NP | 1.02B
4194845 | SO102-2NP | NK11.08.2002 | 2002 | SO102-2NP | 2.01B

# IfcFurniture: Jídelní židle:Z04A_Jídelní židle (11)
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04A; Konstrukce / Materiály: 4-nohá dřevěná podnož z masivního dřeva, bez kluzáků, dřevěný korpus překližka, barevný lak, hmotnost 4,6 kg; Typ nábytku: Jídelní židle; Rozměry: Celkové: 490/525/790 mm (š/h/v); Sedadlo: 436/420/450 mm (š/h/v)
Name (Jídelní židle:Z04A_Jídelní židle:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4155575 | SO102-1NP | NK12.04A.2001 | 2001 | SO102-1NP | 1.02B
4155636 | SO102-1NP | NK12.04A.2002 | 2002 | SO102-1NP | 1.02B
4168207 | SO102-1NP | NK12.04A.2003 | 2003 | SO102-1NP | 1.02C
4168303 | SO102-1NP | NK12.04A.2004 | 2004 | SO102-1NP | 1.02C
4168312 | SO102-1NP | NK12.04A.2005 | 2005 | SO102-1NP | 1.02C
4194848 | SO102-2NP | NK12.04A.2006 | 2006 | SO102-2NP | 2.01B
4194850 | SO102-2NP | NK12.04A.2007 | 2007 | SO102-2NP | 2.01B
4194957 | SO102-2NP | NK12.04A.2008 | 2008 | SO102-2NP | 2.01C
4194959 | SO102-2NP | NK12.04A.2009 | 2009 | SO102-2NP | 2.01C
4194961 | SO102-2NP | NK12.04A.2010 | 2010 | SO102-2NP | 2.01C
4194997 | SO102-2NP | NK12.04A.2011 | 2011 | SO102-2NP | 2.01B

# IfcFurniture: Jídelní židle:Z04B_Jídelní židle (9)
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04B; Konstrukce / Materiály: 4-nohá dřevěná podnož z masivního dřeva, bez kluzáků, dřevěný korpus překližka, barevný lak, hmotnost 4,6 kg; Typ nábytku: Jídelní židle; Rozměry: Celkové: 490/525/790 mm (š/h/v); Sedadlo: 436/420/450 mm (š/h/v)
Name (Jídelní židle:Z04B_Jídelní židle:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4155576 | SO102-1NP | NK12.04B.2001 | 2001 | SO102-1NP | 1.02B
4168208 | SO102-1NP | NK12.04B.2002 | 2002 | SO102-1NP | 1.02C
4168304 | SO102-1NP | NK12.04B.2003 | 2003 | SO102-1NP | 1.02C
4168313 | SO102-1NP | NK12.04B.2004 | 2004 | SO102-1NP | 1.02C
4194849 | SO102-2NP | NK12.04B.2005 | 2005 | SO102-2NP | 2.01B
4194958 | SO102-2NP | NK12.04B.2006 | 2006 | SO102-2NP | 2.01C
4194960 | SO102-2NP | NK12.04B.2007 | 2007 | SO102-2NP | 2.01C
4194962 | SO102-2NP | NK12.04B.2008 | 2008 | SO102-2NP | 2.01C
4195025 | SO102-2NP | NK12.04B.2009 | 2009 | SO102-2NP | 2.01B

# IfcFurniture: Jídelní židle:Z04_Jídelní židle (7)
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: 4-nohá dřevěná podnož ze světlého masivního dřeva, bez kluzáků, dřevěný korpus překližka, bezbarvý lak, hmotnost 4,6 kg; Typ nábytku: Jídelní židle; Rozměry: Celkové: 490/525/790 mm (š/h/v); Sedadlo: 436/420/450 mm (š/h/v)
Name (Jídelní židle:Z04_Jídelní židle:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4155477 | SO102-1NP | NK12.04.2001 | 2001 | SO102-1NP | 1.02B
4155556 | SO102-1NP | NK12.04.2002 | 2002 | SO102-1NP | 1.02B
4168192 | SO102-1NP | NK12.04.2003 | 2003 | SO102-1NP | 1.02C
4194846 | SO102-2NP | NK12.04.2004 | 2004 | SO102-2NP | 2.01B
4194847 | SO102-2NP | NK12.04.2005 | 2005 | SO102-2NP | 2.01B
4194956 | SO102-2NP | NK12.04.2006 | 2006 | SO102-2NP | 2.01C
4195091 | SO102-2NP | NK12.04.2007 | 2007 | SO102-2NP | 2.01B

# IfcFurniture: Kancelářská židle:Z01_Kancelářská židle (40)
In: SO102-2NP
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Nastavitelná výška křesla, s černými pevnými područkami z formované pěny, područky výškově nastavitelné, celočalouněným sedákem a síťovanou opěrou zad. Podnož z leštěného hliníku s pěti rameny, černá kolečka. Čalounění: složení: 97,9% Polyester, 2,1% Spendex. Gramáž: 263,9 g/m2.; Typ nábytku: Kancelářská židle; Rozměry: 700/470/1160-1240 mm (š/h/v)
KIC_PSet - Podlaží: SO102-2NP
Name (Kancelářská židle:Z01_Kancelářská židle:...) | Kód prvku | Označení | Číslo místnosti
4207758 | NK02.01.2001 | 2001 | 2.04
4207794 | NK02.01.2002 | 2002 | 2.04
4207807 | NK02.01.2003 | 2003 | 2.04
4207842 | NK02.01.2004 | 2004 | 2.05
4207846 | NK02.01.2005 | 2005 | 2.05
4207871 | NK02.01.2006 | 2006 | 2.05
4208051 | NK02.01.2007 | 2007 | 2.06
4208055 | NK02.01.2008 | 2008 | 2.06
4208086 | NK02.01.2009 | 2009 | 2.06
4208230 | NK02.01.2010 | 2010 | 2.09
4208315 | NK02.01.2011 | 2011 | 2.10
4208359 | NK02.01.2012 | 2012 | 2.11
4208404 | NK02.01.2013 | 2013 | 2.12
4208463 | NK02.01.2014 | 2014 | 2.12
4208505 | NK02.01.2015 | 2015 | 2.09
4208525 | NK02.01.2016 | 2016 | 2.10
4208541 | NK02.01.2017 | 2017 | 2.11
4208558 | NK02.01.2018 | 2018 | 2.27
4208562 | NK02.01.2019 | 2019 | 2.27
4208609 | NK02.01.2020 | 2020 | 2.27
4208631 | NK02.01.2021 | 2021 | 2.26
4208653 | NK02.01.2022 | 2022 | 2.26
4208675 | NK02.01.2023 | 2023 | 2.25
4208861 | NK02.01.2024 | 2024 | 2.25
4208889 | NK02.01.2025 | 2025 | 2.24
4208945 | NK02.01.2026 | 2026 | 2.24
4208995 | NK02.01.2027 | 2027 | 2.23
4209045 | NK02.01.2028 | 2028 | 2.23
4209121 | NK02.01.2029 | 2029 | 2.22
4209147 | NK02.01.2030 | 2030 | 2.22
4215067 | NK02.01.2031 | 2031 | 2.13
4215135 | NK02.01.2032 | 2032 | 2.13
4215394 | NK02.01.2033 | 2033 | 2.14
4215423 | NK02.01.2034 | 2034 | 2.14
4215469 | NK02.01.2035 | 2035 | 2.15
4215520 | NK02.01.2036 | 2036 | 2.15
4215743 | NK02.01.2037 | 2037 | 2.16
4215761 | NK02.01.2038 | 2038 | 2.16
4215900 | NK02.01.2039 | 2039 | 2.17
4215922 | NK02.01.2040 | 2040 | 2.17

# IfcFurniture: Kancelářský koš:P01_Kancelářský koš (28)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Neuzavíratelný, ocelový, potažený epoxidovou pryskyřicí odolnou proti poškrábání, objem 15 l; Typ nábytku: Kancelářský koš; Rozměry: 260/315 mm (Ø/v)
Name (Kancelářský koš:P01_Kancelářský koš:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4172144 | SO102-1NP | NK14.01.2001 | 2001 | SO102-1NP | 1.19
4180592 | SO102-2NP | NK14.01.2002 | 2002 | SO102-2NP | 2.20
4207795 | SO102-2NP | NK14.01.2004 | 2004 | SO102-2NP | 2.04
4207808 | SO102-2NP | NK14.01.2005 | 2005 | SO102-2NP | 2.04
4207847 | SO102-2NP | NK14.01.2007 | 2007 | SO102-2NP | 2.05
4207872 | SO102-2NP | NK14.01.2008 | 2008 | SO102-2NP | 2.05
4208056 | SO102-2NP | NK14.01.2010 | 2010 | SO102-2NP | 2.06
4208087 | SO102-2NP | NK14.01.2011 | 2011 | SO102-2NP | 2.06
4208316 | SO102-2NP | NK14.01.2013 | 2013 | SO102-2NP | 2.10
4208360 | SO102-2NP | NK14.01.2014 | 2014 | SO102-2NP | 2.11
4208405 | SO102-2NP | NK14.01.2015 | 2015 | SO102-2NP | 2.12
4208506 | SO102-2NP | NK14.01.2017 | 2017 | SO102-2NP | 2.09
4208563 | SO102-2NP | NK14.01.2021 | 2021 | SO102-2NP | 2.27
4208632 | SO102-2NP | NK14.01.2023 | 2023 | SO102-2NP | 2.26
4208676 | SO102-2NP | NK14.01.2025 | 2025 | SO102-2NP | 2.25
4208890 | SO102-2NP | NK14.01.2027 | 2027 | SO102-2NP | 2.24
4208996 | SO102-2NP | NK14.01.2029 | 2029 | SO102-2NP | 2.23
4209122 | SO102-2NP | NK14.01.2031 | 2031 | SO102-2NP | 2.22
4215068 | SO102-2NP | NK14.01.2033 | 2033 | SO102-2NP | 2.13
4215136 | SO102-2NP | NK14.01.2034 | 2034 | SO102-2NP | 2.13
4215395 | SO102-2NP | NK14.01.2035 | 2035 | SO102-2NP | 2.14
4215424 | SO102-2NP | NK14.01.2036 | 2036 | SO102-2NP | 2.14
4215470 | SO102-2NP | NK14.01.2037 | 2037 | SO102-2NP | 2.15
4215502 | SO102-2NP | NK14.01.2038 | 2038 | SO102-2NP | 2.15
4215744 | SO102-2NP | NK14.01.2039 | 2039 | SO102-2NP | 2.16
4215760 | SO102-2NP | NK14.01.2040 | 2040 | SO102-2NP | 2.16
4215901 | SO102-2NP | NK14.01.2041 | 2041 | SO102-2NP | 2.17
4215921 | SO102-2NP | NK14.01.2042 | 2042 | SO102-2NP | 2.17

# IfcFurniture: Kancelářský koš:P01_Kancelářský koš (14)
In: SO102-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Neuzavíratelný, ocelový, potažený epoxidovou pryskyřicí odolnou proti poškrábání, objem 15 l; Typ nábytku: Kancelářský koš; Rozměry: 260/315 mm (Ø/v)
Classification: P (Uniformat)
KIC_PSet - Podlaží: SO102-2NP
Name (Kancelářský koš:P01_Kancelářský koš:...) | Kód prvku | Označení | Číslo místnosti
4207759 | NK14.01.2003 | 2003 | 2.04
4207843 | NK14.01.2006 | 2006 | 2.05
4208052 | NK14.01.2009 | 2009 | 2.06
4208231 | NK14.01.2012 | 2012 | 2.09
4208464 | NK14.01.2016 | 2016 | 2.12
4208526 | NK14.01.2018 | 2018 | 2.10
4208542 | NK14.01.2019 | 2019 | 2.11
4208559 | NK14.01.2020 | 2020 | 2.27
4208610 | NK14.01.2022 | 2022 | 2.27
4208654 | NK14.01.2024 | 2024 | 2.26
4208862 | NK14.01.2026 | 2026 | 2.25
4208946 | NK14.01.2028 | 2028 | 2.24
4209046 | NK14.01.2030 | 2030 | 2.23
4209148 | NK14.01.2032 | 2032 | 2.22

# IfcFurniture: Konferenční stůl:S06_Konferenční stůl (2)
In: SO102-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 06; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Konferenční stůl; Rozměry: 2000/800/735-750 mm (š/h/v)
Classification: S (Uniformat)
KIC_PSet - Podlaží: SO102-2NP; Číslo místnosti: 2.18
Name (Konferenční stůl:S06_Konferenční stůl:...) | Kód prvku | Označení
4193839 | NK03.06.2001 | 2001
4194781 | NK03.06.2002 | 2002

# IfcFurniture: Konferenční židle:Z03A_Konferenční židle (12)
In: SO102-2NP
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03A; Konstrukce / Materiály: 4-ramenný hliníkový kříž, leštěný, kolečka na koberce, černá, Ø 60 mm, hmotnost 8 kg, celočalouněný korpus, tloušťka opěráku 12 mm, tloušťka sedáku 12 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Konferenční židle; Rozměry: 530/580/860 mm (š/h/v); viz nákres
KIC_PSet - Podlaží: SO102-2NP; Číslo místnosti: 2.18
Name (Konferenční židle:Z03A_Konferenční židle:...) | Kód prvku | Označení
4192593 | NK02.03A.2001 | 2001
4193783 | NK02.03A.2002 | 2002
4193791 | NK02.03A.2003 | 2003
4193801 | NK02.03A.2004 | 2004
4193809 | NK02.03A.2005 | 2005
4193817 | NK02.03A.2006 | 2006
4193831 | NK02.03A.2007 | 2007
4193832 | NK02.03A.2008 | 2008
4193833 | NK02.03A.2009 | 2009
4193834 | NK02.03A.2010 | 2010
4193835 | NK02.03A.2011 | 2011
4193836 | NK02.03A.2012 | 2012

# IfcFurniture: Koš na WC:P03_Koš na WC (6)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Nerezový nášlapný odpadkový koš s vnitřní plastovou nádobou, černá povrchová úprava, objem 5l; Typ nábytku: Koš na WC; Rozměry: 205/280 mm (Ø/v)
Name (Koš na WC:P03_Koš na WC:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4168349 | SO102-1NP | NK14.03.2001 | 2001 | SO102-1NP | 1.08B
4170863 | SO102-1NP | NK14.03.2002 | 2002 | SO102-1NP | 1.08B
4170873 | SO102-1NP | NK14.03.2003 | 2003 | SO102-1NP | 1.08B
4179405 | SO102-2NP | NK14.03.2004 | 2004 | SO102-2NP | 2.07B
4179470 | SO102-2NP | NK14.03.2005 | 2005 | SO102-2NP | 2.07B
4179480 | SO102-2NP | NK14.03.2006 | 2006 | SO102-2NP | 2.07B

# IfcFurniture: Koš na tříděný odpad:P02_Koš na tříděný odpad (10)
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Uzavíratelný koš s pedálem vyrobený z polypropyenu, objem 50 l; Typ nábytku: Koš na tříděný odpad; Rozměry: 330/410/625 mm (š/h/v)
Classification: P (Uniformat)
Name (Koš na tříděný odpad:P02_Koš na tříděný odpad:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4164238 | SO102-1NP | NK14.02.2001 | 2001 | SO102-1NP | 1.02B
4164240 | SO102-1NP | NK14.02.2002 | 2002 | SO102-1NP | 1.02B
4179157 | SO102-1NP | NK14.02.2003 | 2003 | SO102-1NP | 1.08A
4180163 | SO102-2NP | NK14.02.2004 | 2004 | SO102-2NP | 2.08A
4180192 | SO102-2NP | NK14.02.2005 | 2005 | SO102-2NP | 2.07A
4180627 | SO102-2NP | NK14.02.2006 | 2006 | SO102-2NP | 2.20
4180666 | SO102-1NP | NK14.02.2007 | 2007 | SO102-1NP | 1.19
4194790 | SO102-2NP | NK14.02.2008 | 2008 | SO102-2NP | 2.01B
4194834 | SO102-2NP | NK14.02.2009 | 2009 | SO102-2NP | 2.01B
4204654 | SO102-1NP | NK14.02.2010 | 2010 | SO102-1NP | 1.09A

# IfcFurniture: Otočné křeslo:SN02_Otočné křeslo (6)
Type - Classification: SN Stěny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: 4-ramenný hliníkový kříž, leštěný, plastové kluzáky na koberce, hmotnost 15 kg, celočalouněný korpus, tlošťka opěráku 65 mm, tloušťka sedáku 65 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Otočné křeslo; Rozměry: 760/770/1000 mm (š/h/v); viz nákres
Name (Otočné křeslo:SN02_Otočné křeslo:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4166141 | SO102-1NP | NK04.02.2001 | 2001 | SO102-1NP | 1.02C
4167118 | SO102-1NP | NK04.02.2002 | 2002 | SO102-1NP | 1.02C
4167128 | SO102-1NP | NK04.02.2003 | 2003 | SO102-1NP | 1.02C
4194950 | SO102-2NP | NK04.02.2004 | 2004 | SO102-2NP | 2.01C
4194951 | SO102-2NP | NK04.02.2005 | 2005 | SO102-2NP | 2.01C
4194952 | SO102-2NP | NK04.02.2006 | 2006 | SO102-2NP | 2.01C

# IfcFurniture: Piktogramy:Cedule s piktogramem - WC imobilní (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 05; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem -WC imobilní; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - WC imobilní:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4323244 | SO102-1NP | NK25.05.2001 | 2001 | SO102-1NP | 1.19
4326750 | SO102-2NP | NK25.05.2002 | 2002 | SO102-2NP | 2.20

# IfcFurniture: Piktogramy:Cedule s piktogramem - WC muži (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem WC muži; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - WC muži:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4322269 | SO102-1NP | NK25.04.2001 | 2001 | SO102-1NP | 1.09A
4326603 | SO102-2NP | NK25.04.2002 | 2002 | SO102-2NP | 2.08A

# IfcFurniture: Piktogramy:Cedule s piktogramem - WC ženy (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem - WC ženy; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - WC ženy:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4323175 | SO102-1NP | NK25.03.2001 | 2001 | SO102-1NP | 1.08A
4326685 | SO102-2NP | NK25.03.2002 | 2002 | SO102-2NP | 2.07A

# IfcFurniture: Piktogramy:Cedule s piktogramem - přebalovací pult (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 06; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem -přebalovací pult; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - přebalovací pult:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4323278 | SO102-1NP | NK25.06.2001 | 2001 | SO102-1NP | 1.19
4326764 | SO102-2NP | NK25.06.2002 | 2002 | SO102-2NP | 2.20

# IfcFurniture: Piktogramy:Cedule s piktogramem - sprcha muži (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 08; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem -sprcha muži; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - sprcha muži:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4323198 | SO102-1NP | NK25.08.2001 | 2001 | SO102-1NP | 1.18
4326706 | SO102-2NP | NK25.08.2002 | 2002 | SO102-2NP | 2.19

# IfcFurniture: Piktogramy:Cedule s piktogramem - sprcha ženy (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 07; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem -sprcha ženy; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - sprcha ženy:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4323260 | SO102-1NP | NK25.07.2001 | 2001 | SO102-1NP | 1.20
4326731 | SO102-2NP | NK25.07.2002 | 2002 | SO102-2NP | 2.21

# IfcFurniture: Pracovní stůl:S01_Pracovní stůl (22)
In: SO102-2NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Pracovní stůl; Rozměry: 1800/800/735 -750 mm (š/h/v)
KIC_PSet - Podlaží: SO102-2NP
Name (Pracovní stůl:S01_Pracovní stůl:...) | Kód prvku | Označení | Číslo místnosti
4191770 | NK03.01.2002 | 2002 | 2.09
4191980 | NK03.01.2005 | 2005 | 2.13
4192081 | NK03.01.2008 | 2008 | 2.14
4192131 | NK03.01.2010 | 2010 | 2.15
4192148 | NK03.01.2011 | 2011 | 2.16
4192213 | NK03.01.2014 | 2014 | 2.17
4192250 | NK03.01.2015 | 2015 | 2.22
4192288 | NK03.01.2017 | 2017 | 2.23
4192353 | NK03.01.2019 | 2019 | 2.24
4192389 | NK03.01.2021 | 2021 | 2.25
4192443 | NK03.01.2023 | 2023 | 2.26
4192499 | NK03.01.2025 | 2025 | 2.27
4192540 | NK03.01.2027 | 2027 | 2.27
4207793 | NK03.01.2029 | 2029 | 2.04
4207806 | NK03.01.2030 | 2030 | 2.04
4207845 | NK03.01.2032 | 2032 | 2.05
4207870 | NK03.01.2033 | 2033 | 2.05
4208054 | NK03.01.2035 | 2035 | 2.06
4208085 | NK03.01.2036 | 2036 | 2.06
4208314 | NK03.01.2037 | 2037 | 2.10
4208358 | NK03.01.2038 | 2038 | 2.11
4208403 | NK03.01.2039 | 2039 | 2.12

# IfcFurniture: Pracovní stůl:S01_Pracovní stůl (18)
In: SO102-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Pracovní stůl; Rozměry: 1800/800/735 -750 mm (š/h/v)
Classification: S (Uniformat)
KIC_PSet - Podlaží: SO102-2NP
Name (Pracovní stůl:S01_Pracovní stůl:...) | Kód prvku | Označení | Číslo místnosti
4191739 | NK03.01.2001 | 2001 | 2.09
4191787 | NK03.01.2003 | 2003 | 2.10
4191843 | NK03.01.2004 | 2004 | 2.11
4192024 | NK03.01.2006 | 2006 | 2.13
4192062 | NK03.01.2007 | 2007 | 2.14
4192108 | NK03.01.2009 | 2009 | 2.15
4192179 | NK03.01.2012 | 2012 | 2.16
4192194 | NK03.01.2013 | 2013 | 2.17
4192271 | NK03.01.2016 | 2016 | 2.22
4192327 | NK03.01.2018 | 2018 | 2.23
4192372 | NK03.01.2020 | 2020 | 2.24
4192404 | NK03.01.2022 | 2022 | 2.25
4192470 | NK03.01.2024 | 2024 | 2.26
4192526 | NK03.01.2026 | 2026 | 2.27
4207757 | NK03.01.2028 | 2028 | 2.04
4207841 | NK03.01.2031 | 2031 | 2.05
4208050 | NK03.01.2034 | 2034 | 2.06
4208462 | NK03.01.2040 | 2040 | 2.12

# IfcFurniture: Pracovní stůl:S02_Pracovní stůl (5)
In: SO102-2NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Pracovní stůl; Rozměry: 1600/800/735-750 mm (š/h/v)
KIC_PSet - Podlaží: SO102-2NP
Name (Pracovní stůl:S02_Pracovní stůl:...) | Kód prvku | Označení | Číslo místnosti
4180690 | NK03.02.2001 | 2001 | 2.04
4186996 | NK03.02.2002 | 2002 | 2.05
4187008 | NK03.02.2003 | 2003 | 2.06
4191907 | NK03.02.2004 | 2004 | 2.12
4192548 | NK03.02.2005 | 2005 | 2.27

# IfcFurniture: Přídavna deska stolu:S04_Přídavna deska stolu (30)
In: SO102-2NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem tl. 25 mm a hranami ABS tl. 2 mm; Typ nábytku: Přídavná deska stolu; Rozměry: 800/600 mm (š/h)
KIC_PSet - Podlaží: SO102-2NP
Name (Přídavna deska stolu:S04_Přídavna deska stolu:...) | Kód prvku | Označení | Číslo místnosti
4187948 | NK03.04.2001 | 2001 | 2.06
4188813 | NK03.04.2002 | 2002 | 2.05
4188829 | NK03.04.2003 | 2003 | 2.04
4191740 | NK03.04.2004 | 2004 | 2.09
4191771 | NK03.04.2005 | 2005 | 2.09
4191788 | NK03.04.2006 | 2006 | 2.10
4191813 | NK03.04.2007 | 2007 | 2.10
4191844 | NK03.04.2008 | 2008 | 2.11
4191996 | NK03.04.2009 | 2009 | 2.13
4192046 | NK03.04.2010 | 2010 | 2.13
4192063 | NK03.04.2011 | 2011 | 2.14
4192082 | NK03.04.2012 | 2012 | 2.14
4192109 | NK03.04.2013 | 2013 | 2.15
4192132 | NK03.04.2014 | 2014 | 2.15
4192149 | NK03.04.2015 | 2015 | 2.16
4192180 | NK03.04.2016 | 2016 | 2.16
4192195 | NK03.04.2017 | 2017 | 2.17
4192214 | NK03.04.2018 | 2018 | 2.17
4192251 | NK03.04.2019 | 2019 | 2.22
4192272 | NK03.04.2020 | 2020 | 2.22
4192289 | NK03.04.2021 | 2021 | 2.23
4192328 | NK03.04.2022 | 2022 | 2.23
4192354 | NK03.04.2023 | 2023 | 2.24
4192373 | NK03.04.2024 | 2024 | 2.24
4192390 | NK03.04.2025 | 2025 | 2.25
4192405 | NK03.04.2026 | 2026 | 2.25
4192444 | NK03.04.2027 | 2027 | 2.26
4192471 | NK03.04.2028 | 2028 | 2.26
4192500 | NK03.04.2029 | 2029 | 2.27
4208357 | NK03.04.2030 | 2030 | 2.11

# IfcFurniture: Sedačka:SN01B_Sedačka, Sedačka:SN01B_Sedačka:4163070
In: SO102-1NP
Type - Classification: SN Stěny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01B; Konstrukce / Materiály: Dvojmístné křeslo, 4-nohá dřevěná podnož ze světlého masivního dřeva, bez kluzáků, hmotnost 24 kg, celočalouněný korpus. Tloušťka opěráku 30 mm, tloušťka sedáku 35 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Sedačka; Rozměry: 1320/760/760 mm (š/h/v); viz nákres
KIC_PSet - Kód prvku: NK07.01B.2001; Označení: 2001; Podlaží: SO102-1NP; Číslo místnosti: 1.02B

# IfcFurniture: Sedačka:SN01C_Sedačka, Sedačka:SN01C_Sedačka:4194895
In: SO102-2NP
Type - Classification: SN Stěny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01C; Konstrukce / Materiály: Dvojmístné křeslo, 4-nohá dřevěná podnož ze světlého masivního dřeva, bez kluzáků, hmotnost 24 kg, celočalouněný korpus. Tloušťka opěráku 30 mm, tloušťka sedáku 35 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Sedačka; Rozměry: 1320/760/760 mm (š/h/v); viz nákres
KIC_PSet - Kód prvku: NK07.01C.2001; Označení: 2001; Podlaží: SO102-2NP; Číslo místnosti: 2.01B

# IfcFurniture: Skříň kancelářská vysoká:SK02_Skříň kancelářská vysoká (43)
In: SO102-2NP
Type - Classification: SK Střešní krytiny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm; Typ nábytku: Skříň kancelářská vysoká; Rozměry: 800/470/2100 mm (š/h/v)
KIC_PSet - Podlaží: SO102-2NP
Name (Skříň kancelářská vysoká:SK02_Skříň kancelářská vysoká:...) | Kód prvku | Označení | Číslo místnosti
4185478 | NK10.02.2001 | 2001 | 2.04
4185502 | NK10.02.2002 | 2002 | 2.04
4185514 | NK10.02.2003 | 2003 | 2.04
4185572 | NK10.02.2007 | 2007 | 2.05
4185573 | NK10.02.2008 | 2008 | 2.05
4185574 | NK10.02.2009 | 2009 | 2.05
4185612 | NK10.02.2013 | 2013 | 2.06
4185613 | NK10.02.2014 | 2014 | 2.06
4185614 | NK10.02.2015 | 2015 | 2.06
4185640 | NK10.02.2016 | 2016 | 2.06
4189180 | NK10.02.2019 | 2019 | 2.09
4189181 | NK10.02.2020 | 2020 | 2.09
4189215 | NK10.02.2021 | 2021 | 2.10
4189257 | NK10.02.2022 | 2022 | 2.10
4189301 | NK10.02.2023 | 2023 | 2.10
4189503 | NK10.02.2025 | 2025 | 2.11
4189504 | NK10.02.2026 | 2026 | 2.11
4189592 | NK10.02.2031 | 2031 | 2.12
4189593 | NK10.02.2032 | 2032 | 2.12
4189675 | NK10.02.2035 | 2035 | 2.13
4189795 | NK10.02.2036 | 2036 | 2.13
4190166 | NK10.02.2039 | 2039 | 2.15
4190167 | NK10.02.2040 | 2040 | 2.15
4190444 | NK10.02.2045 | 2045 | 2.16
4190445 | NK10.02.2046 | 2046 | 2.16
4190605 | NK10.02.2049 | 2049 | 2.17
4190606 | NK10.02.2050 | 2050 | 2.17
4191200 | NK10.02.2053 | 2053 | 2.22
4191201 | NK10.02.2054 | 2054 | 2.22
4191242 | NK10.02.2057 | 2057 | 2.23
4191243 | NK10.02.2058 | 2058 | 2.23
4191294 | NK10.02.2059 | 2059 | 2.18
4191295 | NK10.02.2060 | 2060 | 2.18
4191327 | NK10.02.2061 | 2061 | 2.25
4191328 | NK10.02.2062 | 2062 | 2.25
4191573 | NK10.02.2071 | 2071 | 2.27
4191574 | NK10.02.2072 | 2072 | 2.27
4191590 | NK10.02.2073 | 2073 | 2.27
4191666 | NK10.02.2074 | 2074 | 2.27
4191702 | NK10.02.2075 | 2075 | 2.27
4191716 | NK10.02.2076 | 2076 | 2.27
4191726 | NK10.02.2077 | 2077 | 2.27
4230476 | NK10.02.2078 | 2078 | 2.04

# IfcFurniture: Skříň kancelářská vysoká:SK02_Skříň kancelářská vysoká (37)
In: SO102-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm; Typ nábytku: Skříň kancelářská vysoká; Rozměry: 800/470/2100 mm (š/h/v)
Classification: SK Střešní krytiny (Uniformat)
KIC_PSet - Podlaží: SO102-2NP
Name (Skříň kancelářská vysoká:SK02_Skříň kancelářská vysoká:...) | Kód prvku | Označení | Číslo místnosti
4185544 | NK10.02.2004 | 2004 | 2.04
4185545 | NK10.02.2005 | 2005 | 2.04
4185546 | NK10.02.2006 | 2006 | 2.04
4185594 | NK10.02.2010 | 2010 | 2.05
4185595 | NK10.02.2011 | 2011 | 2.05
4185596 | NK10.02.2012 | 2012 | 2.05
4189147 | NK10.02.2017 | 2017 | 2.09
4189148 | NK10.02.2018 | 2018 | 2.09
4189329 | NK10.02.2024 | 2024 | 2.10
4189520 | NK10.02.2027 | 2027 | 2.11
4189521 | NK10.02.2028 | 2028 | 2.11
4189565 | NK10.02.2029 | 2029 | 2.12
4189566 | NK10.02.2030 | 2030 | 2.12
4189626 | NK10.02.2033 | 2033 | 2.13
4189627 | NK10.02.2034 | 2034 | 2.13
4189959 | NK10.02.2037 | 2037 | 2.14
4189960 | NK10.02.2038 | 2038 | 2.14
4190205 | NK10.02.2041 | 2041 | 2.15
4190206 | NK10.02.2042 | 2042 | 2.15
4190332 | NK10.02.2043 | 2043 | 2.16
4190333 | NK10.02.2044 | 2044 | 2.16
4190555 | NK10.02.2047 | 2047 | 2.17
4190556 | NK10.02.2048 | 2048 | 2.17
4191171 | NK10.02.2051 | 2051 | 2.22
4191172 | NK10.02.2052 | 2052 | 2.22
4191217 | NK10.02.2055 | 2055 | 2.23
4191218 | NK10.02.2056 | 2056 | 2.23
4191350 | NK10.02.2063 | 2063 | 2.24
4191351 | NK10.02.2064 | 2064 | 2.24
4191364 | NK10.02.2065 | 2065 | 2.24
4191437 | NK10.02.2066 | 2066 | 2.25
4191438 | NK10.02.2067 | 2067 | 2.25
4191539 | NK10.02.2068 | 2068 | 2.26
4191540 | NK10.02.2069 | 2069 | 2.26
4191549 | NK10.02.2070 | 2070 | 2.26
4235946 | NK10.02.2079 | 2079 | 2.24
4282947 | NK10.02.2080 | 2080 | 2.26

# IfcFurniture: Skříň šatní:SK01_Skříň šatní (40)
In: SO102-2NP
Type - Classification: SK Střešní krytiny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm; Typ nábytku: Skříň šatní; Rozměry: 600/470/2100 mm (š/h/v)
KIC_PSet - Podlaží: SO102-2NP
Name (Skříň šatní:SK01_Skříň šatní:...) | Kód prvku | Označení | Číslo místnosti
4186706 | NK10.01.2001 | 2001 | 2.04
4186776 | NK10.01.2002 | 2002 | 2.04
4186804 | NK10.01.2003 | 2003 | 2.04
4186825 | NK10.01.2004 | 2004 | 2.05
4186826 | NK10.01.2005 | 2005 | 2.05
4186827 | NK10.01.2006 | 2006 | 2.05
4186858 | NK10.01.2007 | 2007 | 2.06
4186860 | NK10.01.2008 | 2008 | 2.06
4189339 | NK10.01.2009 | 2009 | 2.09
4189370 | NK10.01.2010 | 2010 | 2.09
4189400 | NK10.01.2011 | 2011 | 2.10
4189433 | NK10.01.2012 | 2012 | 2.10
4189473 | NK10.01.2013 | 2013 | 2.11
4189483 | NK10.01.2014 | 2014 | 2.11
4189539 | NK10.01.2015 | 2015 | 2.12
4189645 | NK10.01.2016 | 2016 | 2.13
4190036 | NK10.01.2017 | 2017 | 2.14
4190069 | NK10.01.2018 | 2018 | 2.14
4190128 | NK10.01.2019 | 2019 | 2.15
4190136 | NK10.01.2020 | 2020 | 2.15
4190357 | NK10.01.2021 | 2021 | 2.16
4190427 | NK10.01.2022 | 2022 | 2.16
4190536 | NK10.01.2023 | 2023 | 2.17
4190537 | NK10.01.2024 | 2024 | 2.17
4191129 | NK10.01.2025 | 2025 | 2.22
4191149 | NK10.01.2026 | 2026 | 2.22
4191272 | NK10.01.2027 | 2027 | 2.23
4191273 | NK10.01.2028 | 2028 | 2.23
4191397 | NK10.01.2029 | 2029 | 2.24
4191398 | NK10.01.2030 | 2030 | 2.24
4191416 | NK10.01.2031 | 2031 | 2.25
4191417 | NK10.01.2032 | 2032 | 2.25
4191520 | NK10.01.2033 | 2033 | 2.26
4191521 | NK10.01.2034 | 2034 | 2.26
4191612 | NK10.01.2035 | 2035 | 2.27
4191613 | NK10.01.2036 | 2036 | 2.27
4191627 | NK10.01.2037 | 2037 | 2.27
4212825 | NK10.01.2038 | 2038 | 2.06
4214646 | NK10.01.2039 | 2039 | 2.13
4248589 | NK10.01.2040 | 2040 | 2.10

# IfcFurniture: Sprchová stolička:P15_Sprchová stolička (4)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 15; Konstrukce / Materiály: Konstrukce z plastu - akrylátu s otvory pro manipulaci, nosnost 130 kg; Typ nábytku: Sprchová stolička; Rozměry: 330/275/480 mm (š/h/v)
Name (Sprchová stolička:P15_Sprchová stolička:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4176414 | SO102-1NP | NK18.15.2001 | 2001 | SO102-1NP | 1.18
4179043 | SO102-1NP | NK18.15.2002 | 2002 | SO102-1NP | 1.20
4180446 | SO102-2NP | NK18.15.2003 | 2003 | SO102-2NP | 2.19
4180471 | SO102-2NP | NK18.15.2004 | 2004 | SO102-2NP | 2.21

# IfcFurniture: Stůl exteriérový:EN02_Stůl exteriérový (3)
In: SO102-2NP
Type - Classification: EN (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Konstrukce ocelová pozinkovaná a ošetřená barvou v laku. Podnož tříramenná. Hmotnost: 6,3 kg. Vhodný pro venkovní použití.; Typ nábytku: Stůl exteriérový; Rozměry: 600/720 mm (Ø/v)
KIC_PSet - Podlaží: SO102-2NP; Číslo místnosti: 2.29
Name (Stůl exteriérový:EN02_Stůl exteriérový:...) | Kód prvku | Označení
4196025 | NK11.02.2001 | 2001
4204170 | NK11.02.2002 | 2002
4204180 | NK11.02.2003 | 2003

# IfcFurniture: Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1 (26)
In: SO102-2NP
Type - Classification: KK (Uniformat); Material: <Unnamed>, Plast černý
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm, Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm. Vysunutí zásuvky max. na 75% hloubky. Kontejner je opatřen zámkovým systémem, který centrálně uzavírá a otevírá všechny zásuvky kontejneru a současně blokuje výsuv více než jedné zásuvky.; Typ nábytku: Uzamykatelný mobilní kontejner 3+1; Rozměry: 443/600/602 mm (š/h/v)
KIC_PSet - Podlaží: SO102-2NP
Name (Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1:...) | Kód prvku | Označení | Číslo místnosti
4207796 | NK13.01.2002 | 2002 | 2.04
4207809 | NK13.01.2003 | 2003 | 2.04
4207848 | NK13.01.2005 | 2005 | 2.05
4207873 | NK13.01.2006 | 2006 | 2.05
4208057 | NK13.01.2008 | 2008 | 2.06
4208088 | NK13.01.2009 | 2009 | 2.06
4208317 | NK13.01.2011 | 2011 | 2.10
4208361 | NK13.01.2012 | 2012 | 2.11
4208406 | NK13.01.2013 | 2013 | 2.12
4208507 | NK13.01.2015 | 2015 | 2.09
4208564 | NK13.01.2019 | 2019 | 2.27
4208633 | NK13.01.2021 | 2021 | 2.26
4208677 | NK13.01.2023 | 2023 | 2.25
4208891 | NK13.01.2025 | 2025 | 2.24
4208997 | NK13.01.2027 | 2027 | 2.23
4209123 | NK13.01.2029 | 2029 | 2.22
4215069 | NK13.01.2031 | 2031 | 2.13
4215095 | NK13.01.2032 | 2032 | 2.13
4215396 | NK13.01.2033 | 2033 | 2.14
4215421 | NK13.01.2034 | 2034 | 2.14
4215471 | NK13.01.2035 | 2035 | 2.15
4215501 | NK13.01.2036 | 2036 | 2.15
4215745 | NK13.01.2037 | 2037 | 2.16
4215759 | NK13.01.2038 | 2038 | 2.16
4215902 | NK13.01.2039 | 2039 | 2.17
4215920 | NK13.01.2040 | 2040 | 2.17

# IfcFurniture: Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1 (14)
In: SO102-2NP
Type - Material: <Unnamed>, Plast černý
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm, Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm. Vysunutí zásuvky max. na 75% hloubky. Kontejner je opatřen zámkovým systémem, který centrálně uzavírá a otevírá všechny zásuvky kontejneru a současně blokuje výsuv více než jedné zásuvky.; Typ nábytku: Uzamykatelný mobilní kontejner 3+1; Rozměry: 443/600/602 mm (š/h/v)
Classification: KK (Uniformat)
KIC_PSet - Podlaží: SO102-2NP
Name (Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1:...) | Kód prvku | Označení | Číslo místnosti
4207760 | NK13.01.2001 | 2001 | 2.04
4207844 | NK13.01.2004 | 2004 | 2.05
4208053 | NK13.01.2007 | 2007 | 2.06
4208232 | NK13.01.2010 | 2010 | 2.09
4208465 | NK13.01.2014 | 2014 | 2.12
4208527 | NK13.01.2016 | 2016 | 2.10
4208543 | NK13.01.2017 | 2017 | 2.11
4208560 | NK13.01.2018 | 2018 | 2.27
4208611 | NK13.01.2020 | 2020 | 2.27
4208655 | NK13.01.2022 | 2022 | 2.26
4208863 | NK13.01.2024 | 2024 | 2.25
4208947 | NK13.01.2026 | 2026 | 2.24
4209047 | NK13.01.2028 | 2028 | 2.23
4209149 | NK13.01.2030 | 2030 | 2.22

# IfcFurniture: Věšák stojanový:P14_Věšák stojanový (2)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 14; Konstrukce / Materiály: Konstrukce z masivního dřeva světlé barvy; Typ nábytku: Věšák stojanový; Rozměry: 510/1760 mm (Ø/v)
Name (Věšák stojanový:P14_Věšák stojanový:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4165144 | SO102-1NP | NK17.14.2001 | 2001 | SO102-1NP | 1.02C
4207669 | SO102-2NP | NK17.14.2003 | 2003 | SO102-2NP | 2.01C

# IfcFurniture: Věšák stojanový:P14_Věšák stojanový, Věšák stojanový:P14_Věšák stojanový:4192569
In: SO102-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 14; Konstrukce / Materiály: Konstrukce z masivního dřeva světlé barvy; Typ nábytku: Věšák stojanový; Rozměry: 510/1760 mm (Ø/v)
Classification: P (Uniformat)
KIC_PSet - Kód prvku: NK17.14.2002; Označení: 2002; Podlaží: SO102-2NP; Číslo místnosti: 2.18

# IfcFurniture: Židle jídelní barová exteriérová:EN04_Židle jídelní barová exteriérová (6)
In: SO102-2NP
Type - Classification: EN (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: Konstrukce židle z pozinkované oceli ošetřené práškovou barvou. Hmtnost: 6,1 kg, vhodná pro venkovní použití.; Typ nábytku: Židle barová exteriérová; Rozměry: 465/490/960 mm (š/h/v); výška sedáku: 750 mm
KIC_PSet - Podlaží: SO102-2NP; Číslo místnosti: 2.29
Name (Židle jídelní barová exteriérová:EN04_Židle jídelní barová exteriérová:...) | Kód prvku | Označení
4197958 | NK12.04.2008 | 2008
4204112 | NK12.04.2009 | 2009
4204138 | NK12.04.2010 | 2010
4204139 | NK12.04.2011 | 2011
4204149 | NK12.04.2012 | 2012
4204150 | NK12.04.2013 | 2013

# IfcFurniture: Židle jídelní exteriérová:EN03_Židle jídelní exteriérová (11)
In: SO102-2NP
Type - Classification: EN (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Konstrukce židle z pozinkované oceli ošetřené práškovou barvou. Hmtnost: 5,6 kg. Stohovatelnost: po 10 ks, vhodná pro venkovní použití.; Typ nábytku: Židle jídelní exteriérová; Rozměry: 520/575/800 mm (š/h/v)
KIC_PSet - Podlaží: SO102-2NP; Číslo místnosti: 2.29
Name (Židle jídelní exteriérová:EN03_Židle jídelní exteriérová:...) | Kód prvku | Označení
4198976 | NK12.03.2001 | 2001
4204283 | NK12.03.2002 | 2002
4204342 | NK12.03.2003 | 2003
4204405 | NK12.03.2004 | 2004
4204417 | NK12.03.2005 | 2005
4204418 | NK12.03.2006 | 2006
4204419 | NK12.03.2007 | 2007
4204420 | NK12.03.2008 | 2008
4204441 | NK12.03.2009 | 2009
4204442 | NK12.03.2010 | 2010
4204443 | NK12.03.2011 | 2011
