Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: 220052
Time: 2023-05-18T10:05:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.5.0.0 - Alternate UI 22.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 18 10:05:55 2023 * Host: EBC-74 * Database: C:\Users\VIT~1.VEV\AppData\Local\Temp\dc923746-f19b-479a-b016-3a60ca5012d0\35f7a430-1b4d-4521-bef6-a5ddcc51933e\ifc * Database version: 5507 * Database creation date: Thu May 18 10:05:51 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu May 18 10:05:52 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 18 10:05:52 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 220052
LongName: KARLOVARSKÉ INOVAČNÍ CENTRUM; Phase: DPS

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Podlaží:Podlaží (2)
Name | LongName | Elevation (mm)
SO103-1NP | SO103-1NP | 0
SO103-2NP | SO103-2NP | 4200

# IfcFurniture: Barová židle:Z05A_ Barová židle (6)
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 05A; Konstrukce / Materiály: 4-nohá dřevěná podnož z masivního dřeva, bez kluzáků, dřevěný korpus překližka, barevný lak, hmotnost 5,2 kg; Typ nábytku: Barová židle; Rozměry: Celkové: 490/479/994 mm (š/h/v); Sedadlo: 440/360/780 mm (š/h/v)
Name (Barová židle:Z05A_ Barová židle:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4161106 | SO103-1NP | NK13.05A.3001 | 3001 | SO103-1NP | 1.02B
4163023 | SO103-1NP | NK13.05A.3002 | 3002 | SO103-1NP | 1.02B
4163033 | SO103-1NP | NK13.05A.3003 | 3003 | SO103-1NP | 1.02B
4194853 | SO103-2NP | NK13.05A.3004 | 3004 | SO103-2NP | 2.01B
4194854 | SO103-2NP | NK13.05A.3005 | 3005 | SO103-2NP | 2.01B
4194855 | SO103-2NP | NK13.05A.3006 | 3006 | SO103-2NP | 2.01B

# IfcFurniture: Barový stůl exteriérový:EN01_Barový stůl exteriérový (3)
In: SO103-2NP
Type - Classification: EN (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Konstrukce čtřnohé podnože - ocelová pozinkovaná a ošetřená barvou v laku. Vysoce odolná kompaktní HPL deska odolná proti vlhkosti. Hmotnost: 18 kg. Vhodný pro venkovní použití.; Typ nábytku: Barový stůl; Rozměry: 1200/500/1100 mm (š/h/v)
KIC_PSet - Podlaží: SO103-2NP; Číslo místnosti: 2.29
Name (Barový stůl exteriérový:EN01_Barový stůl exteriérový:...) | Kód prvku | Označení
4196913 | NK11.01.3001 | 3001
4204074 | NK11.01.3002 | 3002
4204084 | NK11.01.3003 | 3003

# IfcFurniture: Barový stůl:S10_Barový stůl (2)
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 10; Konstrukce / Materiály: Deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Podnoží z masivního dřeva světlé barvy; Typ nábytku: Barový stůl; Rozměry: 1800/600/1100 mm (š/h/v)
Name (Barový stůl:S10_Barový stůl:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4161105 | SO103-1NP | NK11.10.3001 | 3001 | SO103-1NP | 1.02B
4194852 | SO103-2NP | NK11.10.3002 | 3002 | SO103-2NP | 2.01B

# IfcFurniture: DVERE-Tabule:informační tabulka (37)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Tabulka se skládá z profilu ze stříbrně eloxovaného hliníku, který je zakončen plastovými bočnicemi šedé barvy. Části se do sebe jednoduše zaklapují. Do profilu se vkládá papírový výtisk chráněný krycím antireflexním plastem nebo gravírovaný pásek z umělé hmoty anebo kovový pásek s natištěnými informacemi. Tabulku je možno dle podkladu přišroubovat nebo přilepit pomocí oboustranné lepenky. V plastových bočnicích jsou otvory pro přišroubování.; Typ nábytku: Informační tabulka; Rozměry: 187/62 mm (š/v)
Name (DVERE-Tabule:informační tabulka:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4328780 | SO103-1NP | NK25.02.3001 | 3001 | SO103-1NP | 1.10
4329685 | SO103-1NP | NK25.02.3002 | 3002 | SO103-1NP | 1.11
4329697 | SO103-1NP | NK25.02.3003 | 3003 | SO103-1NP | 1.11
4329709 | SO103-1NP | NK25.02.3004 | 3004 | SO103-1NP | 1.11
4329766 | SO103-1NP | NK25.02.3005 | 3005 | SO103-1NP | 1.06
4329822 | SO103-1NP | NK25.02.3006 | 3006 | SO103-1NP | 1.06
4329832 | SO103-1NP | NK25.02.3007 | 3007 | SO103-1NP | 1.05
4329842 | SO103-1NP | NK25.02.3008 | 3008 | SO103-1NP | 1.05
4329906 | SO103-1NP | NK25.02.3009 | 3009 | SO103-1NP | 1.13
4329924 | SO103-1NP | NK25.02.3010 | 3010 | SO103-1NP | 1.13
4329944 | SO103-1NP | NK25.02.3011 | 3011 | SO103-1NP | 1.12
4329956 | SO103-1NP | NK25.02.3012 | 3012 | SO103-1NP | 1.12
4330040 | SO103-1NP | NK25.02.3013 | 3013 | SO103-1NP | 1.22
4330052 | SO103-1NP | NK25.02.3014 | 3014 | SO103-1NP | 1.22
4330064 | SO103-1NP | NK25.02.3015 | 3015 | SO103-1NP | 1.23
4330076 | SO103-1NP | NK25.02.3016 | 3016 | SO103-1NP | 1.23
4330127 | SO103-1NP | NK25.02.3017 | 3017 | SO103-1NP | 1.15
4330184 | SO103-1NP | NK25.02.3018 | 3018 | SO103-1NP | 1.14
4331927 | SO103-2NP | NK25.02.3019 | 3019 | SO103-2NP | 2.06
4331961 | SO103-2NP | NK25.02.3020 | 3020 | SO103-2NP | 2.05
4331975 | SO103-2NP | NK25.02.3021 | 3021 | SO103-2NP | 2.05
4331989 | SO103-2NP | NK25.02.3022 | 3022 | SO103-2NP | 2.04
4332144 | SO103-2NP | NK25.02.3023 | 3023 | SO103-2NP | 2.22
4332180 | SO103-2NP | NK25.02.3024 | 3024 | SO103-2NP | 2.23
4332218 | SO103-2NP | NK25.02.3025 | 3025 | SO103-2NP | 2.24
4332232 | SO103-2NP | NK25.02.3026 | 3026 | SO103-2NP | 2.25
4332248 | SO103-2NP | NK25.02.3027 | 3027 | SO103-2NP | 2.26
4332256 | SO103-2NP | NK25.02.3028 | 3028 | SO103-2NP | 2.27
4332368 | SO103-2NP | NK25.02.3029 | 3029 | SO103-2NP | 2.09
4332388 | SO103-2NP | NK25.02.3030 | 3030 | SO103-2NP | 2.10
4332398 | SO103-2NP | NK25.02.3031 | 3031 | SO103-2NP | 2.11
4332464 | SO103-2NP | NK25.02.3032 | 3032 | SO103-2NP | 2.12
4332539 | SO103-2NP | NK25.02.3033 | 3033 | SO103-2NP | 2.17
4332579 | SO103-2NP | NK25.02.3033 | 3033 | SO103-2NP | 2.16
4332591 | SO103-2NP | NK25.02.3034 | 3034 | SO103-2NP | 2.15
4332603 | SO103-2NP | NK25.02.3035 | 3035 | SO103-2NP | 2.14
4332615 | SO103-2NP | NK25.02.3036 | 3036 | SO103-2NP | 2.13

# IfcFurniture: Háček na dveře WC:P06_Háček na dveře, Háček na dveře WC:P06_Háček na dveře:4170985
In: SO103-1NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 06; Konstrukce / Materiály: Nerezový háček s matně černou povrchovou úpravou, lepený; Typ nábytku: Háček na dveře WC; Rozměry: 48 mm (Ø)
Classification: P (Uniformat)
KIC_PSet - Kód prvku: NK17.06.3037; Označení: 3037; Podlaží: SO103-1NP

# IfcFurniture: INFO-Tabule:Hlavní orientační tabule (2)
In: SO103-1NP
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Tabule ze stříbrně eloxovaného hliníkového systému. Jednotlivé profily jsou do sebe zacvaknuty. Hliníkové bočnice jsou ze stejného materiálu i stejné barvy. Na horním i dolním konci obou bočnic jsou přišroubovány černé plastové krytky. Celá hlavní orientační tabule je nalepena na nosné plastové desce, v které jsou vyvrtány otvory pro montáž celého panelu na zeď. Informační text je řešen polepením fóliovou grafikou dle požadavků.; Typ nábytku: Hlavní orientační tabule; Rozměry: 1218/656 mm (š/v)
KIC_PSet - Podlaží: SO103-1NP; Číslo místnosti: 1.01
Name (INFO-Tabule:Hlavní orientační tabule:...) | Kód prvku | Označení
4330697 | NK25.01.3001 | 3001
4331575 | NK25.01.3002 | 3002

# IfcFurniture: Jídelní stůl kulatý:S07_Jídelní stůl (7)
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 07; Konstrukce / Materiály: Deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Podnoží z masivního dřeva světlé barvy 4 nohy.; Typ nábytku: Jídelní stůl; Rozměry: 900/750 mm (Ø/v)
Name (Jídelní stůl kulatý:S07_Jídelní stůl:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4167189 | SO103-1NP | NK11.07.3001 | 3001 | SO103-1NP | 1.02C
4168141 | SO103-1NP | NK11.07.3002 | 3002 | SO103-1NP | 1.02C
4168151 | SO103-1NP | NK11.07.3003 | 3003 | SO103-1NP | 1.02C
4194953 | SO103-2NP | NK11.07.3004 | 3004 | SO103-2NP | 2.01C
4194954 | SO103-2NP | NK11.07.3005 | 3005 | SO103-2NP | 2.01C
4194955 | SO103-2NP | NK11.07.3006 | 3006 | SO103-2NP | 2.01C
4194996 | SO103-2NP | NK11.07.3007 | 3007 | SO103-2NP | 2.01B

# IfcFurniture: Jídelní stůl:S08_Jídelní stůl (2)
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 08; Konstrukce / Materiály: Deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Podnoží z masivního dřeva světlé barvy; Typ nábytku: Jídelní stůl; Rozměry: 2000/800/750 mm (š/h/v)
Name (Jídelní stůl:S08_Jídelní stůl:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4155416 | SO103-1NP | NK11.08.3001 | 3001 | SO103-1NP | 1.02B
4194845 | SO103-2NP | NK11.08.3002 | 3002 | SO103-2NP | 2.01B

# IfcFurniture: Jídelní židle:Z04A_Jídelní židle (11)
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04A; Konstrukce / Materiály: 4-nohá dřevěná podnož z masivního dřeva, bez kluzáků, dřevěný korpus překližka, barevný lak, hmotnost 4,6 kg; Typ nábytku: Jídelní židle; Rozměry: Celkové: 490/525/790 mm (š/h/v); Sedadlo: 436/420/450 mm (š/h/v)
Name (Jídelní židle:Z04A_Jídelní židle:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4155575 | SO103-1NP | NK12.04A.3001 | 3001 | SO103-1NP | 1.02B
4155636 | SO103-1NP | NK12.04A.3002 | 3002 | SO103-1NP | 1.02B
4168207 | SO103-1NP | NK12.04A.3003 | 3003 | SO103-1NP | 1.02C
4168303 | SO103-1NP | NK12.04A.3004 | 3004 | SO103-1NP | 1.02C
4168312 | SO103-1NP | NK12.04A.3005 | 3005 | SO103-1NP | 1.02C
4194848 | SO103-2NP | NK12.04A.3006 | 3006 | SO103-2NP | 2.01B
4194850 | SO103-2NP | NK12.04A.3007 | 3007 | SO103-2NP | 2.01B
4194957 | SO103-2NP | NK12.04A.3008 | 3008 | SO103-2NP | 2.01C
4194959 | SO103-2NP | NK12.04A.3009 | 3009 | SO103-2NP | 2.01C
4194961 | SO103-2NP | NK12.04A.3010 | 3010 | SO103-2NP | 2.01C
4194997 | SO103-2NP | NK12.04A.3011 | 3011 | SO103-2NP | 2.01B

# IfcFurniture: Jídelní židle:Z04B_Jídelní židle (9)
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04B; Konstrukce / Materiály: 4-nohá dřevěná podnož z masivního dřeva, bez kluzáků, dřevěný korpus překližka, barevný lak, hmotnost 4,6 kg; Typ nábytku: Jídelní židle; Rozměry: Celkové: 490/525/790 mm (š/h/v); Sedadlo: 436/420/450 mm (š/h/v)
Name (Jídelní židle:Z04B_Jídelní židle:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4155576 | SO103-1NP | NK12.04B.3001 | 3001 | SO103-1NP | 1.02B
4168208 | SO103-1NP | NK12.04B.3002 | 3002 | SO103-1NP | 1.02C
4168304 | SO103-1NP | NK12.04B.3003 | 3003 | SO103-1NP | 1.02C
4168313 | SO103-1NP | NK12.04B.3004 | 3004 | SO103-1NP | 1.02C
4194849 | SO103-2NP | NK12.04B.3005 | 3005 | SO103-2NP | 2.01B
4194958 | SO103-2NP | NK12.04B.3006 | 3006 | SO103-2NP | 2.01C
4194960 | SO103-2NP | NK12.04B.3007 | 3007 | SO103-2NP | 2.01C
4194962 | SO103-2NP | NK12.04B.3008 | 3008 | SO103-2NP | 2.01C
4195025 | SO103-2NP | NK12.04B.3009 | 3009 | SO103-2NP | 2.01B

# IfcFurniture: Jídelní židle:Z04_Jídelní židle (7)
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: 4-nohá dřevěná podnož ze světlého masivního dřeva, bez kluzáků, dřevěný korpus překližka, bezbarvý lak, hmotnost 4,6 kg; Typ nábytku: Jídelní židle; Rozměry: Celkové: 490/525/790 mm (š/h/v); Sedadlo: 436/420/450 mm (š/h/v)
Name (Jídelní židle:Z04_Jídelní židle:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4155477 | SO103-1NP | NK12.04.3001 | 3001 | SO103-1NP | 1.02B
4155556 | SO103-1NP | NK12.04.3002 | 3002 | SO103-1NP | 1.02B
4168192 | SO103-1NP | NK12.04.3003 | 3003 | SO103-1NP | 1.02C
4194846 | SO103-2NP | NK12.04.3004 | 3004 | SO103-2NP | 2.01B
4194847 | SO103-2NP | NK12.04.3005 | 3005 | SO103-2NP | 2.01B
4194956 | SO103-2NP | NK12.04.3006 | 3006 | SO103-2NP | 2.01C
4195091 | SO103-2NP | NK12.04.3007 | 3007 | SO103-2NP | 2.01B

# IfcFurniture: Kancelářská židle:Z01_Kancelářská židle (40)
In: SO103-2NP
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Nastavitelná výška křesla, s černými pevnými područkami z formované pěny, područky výškově nastavitelné, celočalouněným sedákem a síťovanou opěrou zad. Podnož z leštěného hliníku s pěti rameny, černá kolečka. Čalounění: složení: 97,9% Polyester, 2,1% Spendex. Gramáž: 263,9 g/m2.; Typ nábytku: Kancelářská židle; Rozměry: 700/470/1160-1240 mm (š/h/v)
KIC_PSet - Podlaží: SO103-2NP
Name (Kancelářská židle:Z01_Kancelářská židle:...) | Kód prvku | Označení | Číslo místnosti
4207758 | NK02.01.3001 | 3001 | 2.04
4207794 | NK02.01.3002 | 3002 | 2.04
4207807 | NK02.01.3003 | 3003 | 2.04
4207842 | NK02.01.3004 | 3004 | 2.05
4207846 | NK02.01.3005 | 3005 | 2.05
4207871 | NK02.01.3006 | 3006 | 2.05
4208051 | NK02.01.3007 | 3007 | 2.06
4208055 | NK02.01.3008 | 3008 | 2.06
4208086 | NK02.01.3009 | 3009 | 2.06
4208230 | NK02.01.3010 | 3010 | 2.09
4208315 | NK02.01.3011 | 3011 | 2.10
4208359 | NK02.01.3012 | 3012 | 2.11
4208404 | NK02.01.3013 | 3013 | 2.12
4208463 | NK02.01.3014 | 3014 | 2.12
4208505 | NK02.01.3015 | 3015 | 2.09
4208525 | NK02.01.3016 | 3016 | 2.10
4208541 | NK02.01.3017 | 3017 | 2.11
4208558 | NK02.01.3018 | 3018 | 2.27
4208562 | NK02.01.3019 | 3019 | 2.27
4208609 | NK02.01.3020 | 3020 | 2.27
4208631 | NK02.01.3021 | 3021 | 2.26
4208653 | NK02.01.3022 | 3022 | 2.26
4208675 | NK02.01.3023 | 3023 | 2.25
4208861 | NK02.01.3024 | 3024 | 2.25
4208889 | NK02.01.3025 | 3025 | 2.24
4208945 | NK02.01.3026 | 3026 | 2.24
4208995 | NK02.01.3027 | 3027 | 2.23
4209045 | NK02.01.3028 | 3028 | 2.23
4209121 | NK02.01.3029 | 3029 | 2.22
4209147 | NK02.01.3030 | 3030 | 2.22
4215067 | NK02.01.3031 | 3031 | 2.13
4215135 | NK02.01.3032 | 3032 | 2.13
4215394 | NK02.01.3033 | 3033 | 2.14
4215423 | NK02.01.3034 | 3034 | 2.14
4215469 | NK02.01.3035 | 3035 | 2.15
4215520 | NK02.01.3036 | 3036 | 2.15
4215743 | NK02.01.3037 | 3037 | 2.16
4215761 | NK02.01.3038 | 3038 | 2.16
4215900 | NK02.01.3039 | 3039 | 2.17
4215922 | NK02.01.3040 | 3040 | 2.17

# IfcFurniture: Kancelářský koš:P01_Kancelářský koš (28)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Neuzavíratelný, ocelový, potažený epoxidovou pryskyřicí odolnou proti poškrábání, objem 15 l; Typ nábytku: Kancelářský koš; Rozměry: 260/315 mm (Ø/v)
Name (Kancelářský koš:P01_Kancelářský koš:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4172144 | SO103-1NP | NK14.01.3001 | 3001 | SO103-1NP | 1.19
4180592 | SO103-2NP | NK14.01.3002 | 3002 | SO103-2NP | 2.20
4207795 | SO103-2NP | NK14.01.3004 | 3004 | SO103-2NP | 2.04
4207808 | SO103-2NP | NK14.01.3005 | 3005 | SO103-2NP | 2.04
4207847 | SO103-2NP | NK14.01.3007 | 3007 | SO103-2NP | 2.05
4207872 | SO103-2NP | NK14.01.3008 | 3008 | SO103-2NP | 2.05
4208056 | SO103-2NP | NK14.01.3010 | 3010 | SO103-2NP | 2.06
4208087 | SO103-2NP | NK14.01.3011 | 3011 | SO103-2NP | 2.06
4208316 | SO103-2NP | NK14.01.3013 | 3013 | SO103-2NP | 2.10
4208360 | SO103-2NP | NK14.01.3014 | 3014 | SO103-2NP | 2.11
4208405 | SO103-2NP | NK14.01.3015 | 3015 | SO103-2NP | 2.12
4208506 | SO103-2NP | NK14.01.3017 | 3017 | SO103-2NP | 2.09
4208563 | SO103-2NP | NK14.01.3021 | 3021 | SO103-2NP | 2.27
4208632 | SO103-2NP | NK14.01.3023 | 3023 | SO103-2NP | 2.26
4208676 | SO103-2NP | NK14.01.3025 | 3025 | SO103-2NP | 2.25
4208890 | SO103-2NP | NK14.01.3027 | 3027 | SO103-2NP | 2.24
4208996 | SO103-2NP | NK14.01.3029 | 3029 | SO103-2NP | 2.23
4209122 | SO103-2NP | NK14.01.3031 | 3031 | SO103-2NP | 2.22
4215068 | SO103-2NP | NK14.01.3033 | 3033 | SO103-2NP | 2.13
4215136 | SO103-2NP | NK14.01.3034 | 3034 | SO103-2NP | 2.13
4215395 | SO103-2NP | NK14.01.3035 | 3035 | SO103-2NP | 2.14
4215424 | SO103-2NP | NK14.01.3036 | 3036 | SO103-2NP | 2.14
4215470 | SO103-2NP | NK14.01.3037 | 3037 | SO103-2NP | 2.15
4215502 | SO103-2NP | NK14.01.3038 | 3038 | SO103-2NP | 2.15
4215744 | SO103-2NP | NK14.01.3039 | 3039 | SO103-2NP | 2.16
4215760 | SO103-2NP | NK14.01.3040 | 3040 | SO103-2NP | 2.16
4215901 | SO103-2NP | NK14.01.3041 | 3041 | SO103-2NP | 2.17
4215921 | SO103-2NP | NK14.01.3042 | 3042 | SO103-2NP | 2.17

# IfcFurniture: Kancelářský koš:P01_Kancelářský koš (14)
In: SO103-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Neuzavíratelný, ocelový, potažený epoxidovou pryskyřicí odolnou proti poškrábání, objem 15 l; Typ nábytku: Kancelářský koš; Rozměry: 260/315 mm (Ø/v)
Classification: P (Uniformat)
KIC_PSet - Podlaží: SO103-2NP
Name (Kancelářský koš:P01_Kancelářský koš:...) | Kód prvku | Označení | Číslo místnosti
4207759 | NK14.01.3003 | 3003 | 2.04
4207843 | NK14.01.3006 | 3006 | 2.05
4208052 | NK14.01.3009 | 3009 | 2.06
4208231 | NK14.01.3012 | 3012 | 2.09
4208464 | NK14.01.3016 | 3016 | 2.12
4208526 | NK14.01.3018 | 3018 | 2.10
4208542 | NK14.01.3019 | 3019 | 2.11
4208559 | NK14.01.3020 | 3020 | 2.27
4208610 | NK14.01.3022 | 3022 | 2.27
4208654 | NK14.01.3024 | 3024 | 2.26
4208862 | NK14.01.3026 | 3026 | 2.25
4208946 | NK14.01.3028 | 3028 | 2.24
4209046 | NK14.01.3030 | 3030 | 2.23
4209148 | NK14.01.3032 | 3032 | 2.22

# IfcFurniture: Konferenční stůl:S06_Konferenční stůl (2)
In: SO103-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 06; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky: 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Konferenční stůl; Rozměry: 2000/800/735-750 mm (š/h/v)
Classification: S (Uniformat)
KIC_PSet - Podlaží: SO103-2NP; Číslo místnosti: 2.18
Name (Konferenční stůl:S06_Konferenční stůl:...) | Kód prvku | Označení
4193839 | NK03.06.3001 | 3001
4194781 | NK03.06.3002 | 3002

# IfcFurniture: Konferenční židle:Z03A_Konferenční židle (12)
In: SO103-2NP
Type - Classification: Z (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03A; Konstrukce / Materiály: 4-ramenný hliníkový kříž, leštěný, kolečka na koberce, černá, Ø 60 mm, hmotnost 8 kg, celočalouněný korpus, tloušťka opěráku 12 mm, tloušťka sedáku 12 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Konferenční židle; Rozměry: 530/580/860 mm (š/h/v); viz nákres
KIC_PSet - Podlaží: SO103-2NP; Číslo místnosti: 2.18
Name (Konferenční židle:Z03A_Konferenční židle:...) | Kód prvku | Označení
4192593 | NK02.03A.3001 | 3001
4193783 | NK02.03A.3002 | 3002
4193791 | NK02.03A.3003 | 3003
4193801 | NK02.03A.3004 | 3004
4193809 | NK02.03A.3005 | 3005
4193817 | NK02.03A.3006 | 3006
4193831 | NK02.03A.3007 | 3007
4193832 | NK02.03A.3008 | 3008
4193833 | NK02.03A.3009 | 3009
4193834 | NK02.03A.3010 | 3010
4193835 | NK02.03A.3011 | 3011
4193836 | NK02.03A.3012 | 3012

# IfcFurniture: Koš na WC:P03_Koš na WC (6)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Nerezový nášlapný odpadkový koš s vnitřní plastovou nádobou, černá povrchová úprava, objem 5l; Typ nábytku: Koš na WC; Rozměry: 205/280 mm (Ø/v)
Name (Koš na WC:P03_Koš na WC:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4168349 | SO103-1NP | NK14.03.3001 | 3001 | SO103-1NP | 1.08B
4170863 | SO103-1NP | NK14.03.3002 | 3002 | SO103-1NP | 1.08B
4170873 | SO103-1NP | NK14.03.3003 | 3003 | SO103-1NP | 1.08B
4179405 | SO103-2NP | NK14.03.3004 | 3004 | SO103-2NP | 2.07B
4179470 | SO103-2NP | NK14.03.3005 | 3005 | SO103-2NP | 2.07B
4179480 | SO103-2NP | NK14.03.3006 | 3006 | SO103-2NP | 2.07B

# IfcFurniture: Koš na tříděný odpad:P02_Koš na tříděný odpad (10)
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Uzavíratelný koš s pedálem vyrobený z polypropyenu, objem 50 l; Typ nábytku: Koš na tříděný odpad; Rozměry: 330/410/625 mm (š/h/v)
Classification: P (Uniformat)
Name (Koš na tříděný odpad:P02_Koš na tříděný odpad:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4164238 | SO103-1NP | NK14.02.3001 | 3001 | SO103-1NP | 1.02B
4164240 | SO103-1NP | NK14.02.3002 | 3002 | SO103-1NP | 1.02B
4179157 | SO103-1NP | NK14.02.3003 | 3003 | SO103-1NP | 1.08A
4180163 | SO103-2NP | NK14.02.3004 | 3004 | SO103-2NP | 2.08A
4180192 | SO103-2NP | NK14.02.3005 | 3005 | SO103-2NP | 2.07A
4180627 | SO103-2NP | NK14.02.3006 | 3006 | SO103-2NP | 2.20
4180666 | SO103-1NP | NK14.02.3007 | 3007 | SO103-1NP | 1.19
4194790 | SO103-2NP | NK14.02.3008 | 3008 | SO103-2NP | 2.01B
4194834 | SO103-2NP | NK14.02.3009 | 3009 | SO103-2NP | 2.01B
4204654 | SO103-1NP | NK14.02.3010 | 3010 | SO103-1NP | 1.09A

# IfcFurniture: Otočné křeslo:SN02_Otočné křeslo (6)
Type - Classification: SN Stěny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: 4-ramenný hliníkový kříž, leštěný, plastové kluzáky na koberce, hmotnost 15 kg, celočalouněný korpus, tlošťka opěráku 65 mm, tloušťka sedáku 65 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Otočné křeslo; Rozměry: 760/770/1000 mm (š/h/v); viz nákres
Name (Otočné křeslo:SN02_Otočné křeslo:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4166141 | SO103-1NP | NK04.02.3001 | 3001 | SO103-1NP | 1.02C
4167118 | SO103-1NP | NK04.02.3002 | 3002 | SO103-1NP | 1.02C
4167128 | SO103-1NP | NK04.02.3003 | 3003 | SO103-1NP | 1.02C
4194950 | SO103-2NP | NK04.02.3004 | 3004 | SO103-2NP | 2.01C
4194951 | SO103-2NP | NK04.02.3005 | 3005 | SO103-2NP | 2.01C
4194952 | SO103-2NP | NK04.02.3006 | 3006 | SO103-2NP | 2.01C

# IfcFurniture: Piktogramy:Cedule s piktogramem - WC imobilní (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 05; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem -WC imobilní; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - WC imobilní:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4326904 | SO103-1NP | NK25.05.3001 | 3001 | SO103-1NP | 1.19
4331802 | SO103-2NP | NK25.05.3002 | 3002 | SO103-2NP | 2.20

# IfcFurniture: Piktogramy:Cedule s piktogramem - WC muži (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem WC muži; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - WC muži:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4326791 | SO103-1NP | NK25.04.3001 | 3001 | SO103-1NP | 1.09A
4331704 | SO103-2NP | NK25.04.3002 | 3002 | SO103-2NP | 2.08A

# IfcFurniture: Piktogramy:Cedule s piktogramem - WC ženy (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem - WC ženy; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - WC ženy:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4326842 | SO103-1NP | NK25.03.3001 | 3001 | SO103-1NP | 1.08A
4331736 | SO103-2NP | NK25.03.3002 | 3002 | SO103-2NP | 2.07A

# IfcFurniture: Piktogramy:Cedule s piktogramem - přebalovací pult (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 06; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem -přebalovací pult; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - přebalovací pult:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4326960 | SO103-1NP | NK25.06.3001 | 3001 | SO103-1NP | 1.19
4331818 | SO103-2NP | NK25.06.3002 | 3002 | SO103-2NP | 2.20

# IfcFurniture: Piktogramy:Cedule s piktogramem - sprcha muži (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 08; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem -sprcha muži; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - sprcha muži:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4326860 | SO103-1NP | NK25.08.3001 | 3001 | SO103-1NP | 1.18
4331752 | SO103-2NP | NK25.08.3002 | 3002 | SO103-2NP | 2.19

# IfcFurniture: Piktogramy:Cedule s piktogramem - sprcha ženy (2)
Type - Classification: IS (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 07; Konstrukce / Materiály: Nerezový piktogram s obrázkem v tmavě šedé barvě. Připevněn na dveře oboustrannou samolepící páskou; Typ nábytku: Cedule s piktogramem -sprcha ženy; Rozměry: 120/120/0,8 mm (š/d/tl)
Name (Piktogramy:Cedule s piktogramem - sprcha ženy:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4326884 | SO103-1NP | NK25.07.3001 | 3001 | SO103-1NP | 1.20
4331772 | SO103-2NP | NK25.07.3002 | 3002 | SO103-2NP | 2.21

# IfcFurniture: Pracovní stůl:S01_Pracovní stůl (22)
In: SO103-2NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Pracovní stůl; Rozměry: 1800/800/735 -750 mm (š/h/v)
KIC_PSet - Podlaží: SO103-2NP
Name (Pracovní stůl:S01_Pracovní stůl:...) | Kód prvku | Označení | Číslo místnosti
4191770 | NK03.01.3002 | 3002 | 2.09
4191980 | NK03.01.3005 | 3005 | 2.13
4192081 | NK03.01.3008 | 3008 | 2.14
4192131 | NK03.01.3010 | 3010 | 2.15
4192148 | NK03.01.3011 | 3011 | 2.16
4192213 | NK03.01.3014 | 3014 | 2.17
4192250 | NK03.01.3015 | 3015 | 2.22
4192288 | NK03.01.3017 | 3017 | 2.23
4192353 | NK03.01.3019 | 3019 | 2.24
4192389 | NK03.01.3021 | 3021 | 2.25
4192443 | NK03.01.3023 | 3023 | 2.26
4192499 | NK03.01.3025 | 3025 | 2.27
4192540 | NK03.01.3027 | 3027 | 2.27
4207793 | NK03.01.3029 | 3029 | 2.04
4207806 | NK03.01.3030 | 3030 | 2.04
4207845 | NK03.01.3032 | 3032 | 2.05
4207870 | NK03.01.3033 | 3033 | 2.05
4208054 | NK03.01.3035 | 3035 | 2.06
4208085 | NK03.01.3036 | 3036 | 2.06
4208314 | NK03.01.3037 | 3037 | 2.10
4208358 | NK03.01.3038 | 3038 | 2.11
4208403 | NK03.01.3039 | 3039 | 2.12

# IfcFurniture: Pracovní stůl:S01_Pracovní stůl (18)
In: SO103-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Pracovní stůl; Rozměry: 1800/800/735 -750 mm (š/h/v)
Classification: S (Uniformat)
KIC_PSet - Podlaží: SO103-2NP
Name (Pracovní stůl:S01_Pracovní stůl:...) | Kód prvku | Označení | Číslo místnosti
4191739 | NK03.01.3001 | 3001 | 2.09
4191787 | NK03.01.3003 | 3003 | 2.10
4191843 | NK03.01.3004 | 3004 | 2.11
4192024 | NK03.01.3006 | 3006 | 2.13
4192062 | NK03.01.3007 | 3007 | 2.14
4192108 | NK03.01.3009 | 3009 | 2.15
4192179 | NK03.01.3012 | 3012 | 2.16
4192194 | NK03.01.3013 | 3013 | 2.17
4192271 | NK03.01.3016 | 3016 | 2.22
4192327 | NK03.01.3018 | 3018 | 2.23
4192372 | NK03.01.3020 | 3020 | 2.24
4192404 | NK03.01.3022 | 3022 | 2.25
4192470 | NK03.01.3024 | 3024 | 2.26
4192526 | NK03.01.3026 | 3026 | 2.27
4207757 | NK03.01.3028 | 3028 | 2.04
4207841 | NK03.01.3031 | 3031 | 2.05
4208050 | NK03.01.3034 | 3034 | 2.06
4208462 | NK03.01.3040 | 3040 | 2.12

# IfcFurniture: Pracovní stůl:S02_Pracovní stůl (5)
In: SO103-2NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem a hranami ABS tl. 2 mm, tl. desky 25 mm. Kovové podnoží ve tvaru A s finální práškovou vrstvou - 2x Noha A, 1x most, 2x horizontální nosník; Typ nábytku: Pracovní stůl; Rozměry: 1600/800/735-750 mm (š/h/v)
KIC_PSet - Podlaží: SO103-2NP
Name (Pracovní stůl:S02_Pracovní stůl:...) | Kód prvku | Označení | Číslo místnosti
4180690 | NK03.02.3001 | 3001 | 2.04
4186996 | NK03.02.3002 | 3002 | 2.05
4187008 | NK03.02.3003 | 3003 | 2.06
4191907 | NK03.02.3004 | 3004 | 2.12
4192548 | NK03.02.3005 | 3005 | 2.27

# IfcFurniture: Přídavna deska stolu:S04_Přídavna deska stolu (30)
In: SO103-2NP
Type - Classification: S (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: Pracovní deska: dřevotřísková deska s melaminovým potahem tl. 25 mm a hranami ABS tl. 2 mm; Typ nábytku: Přídavná deska stolu; Rozměry: 800/600 mm (š/h)
KIC_PSet - Podlaží: SO103-2NP
Name (Přídavna deska stolu:S04_Přídavna deska stolu:...) | Kód prvku | Označení | Číslo místnosti
4187948 | NK03.04.3001 | 3001 | 2.06
4188813 | NK03.04.3002 | 3002 | 2.05
4188829 | NK03.04.3003 | 3003 | 2.04
4191740 | NK03.04.3004 | 3004 | 2.09
4191771 | NK03.04.3005 | 3005 | 2.09
4191788 | NK03.04.3006 | 3006 | 2.10
4191813 | NK03.04.3007 | 3007 | 2.10
4191844 | NK03.04.3008 | 3008 | 2.11
4191996 | NK03.04.3009 | 3009 | 2.13
4192046 | NK03.04.3010 | 3010 | 2.13
4192063 | NK03.04.3011 | 3011 | 2.14
4192082 | NK03.04.3012 | 3012 | 2.14
4192109 | NK03.04.3013 | 3013 | 2.15
4192132 | NK03.04.3014 | 3014 | 2.15
4192149 | NK03.04.3015 | 3015 | 2.16
4192180 | NK03.04.3016 | 3016 | 2.16
4192195 | NK03.04.3017 | 3017 | 2.17
4192214 | NK03.04.3018 | 3018 | 2.17
4192251 | NK03.04.3019 | 3019 | 2.22
4192272 | NK03.04.3020 | 3020 | 2.22
4192289 | NK03.04.3021 | 3021 | 2.23
4192328 | NK03.04.3022 | 3022 | 2.23
4192354 | NK03.04.3023 | 3023 | 2.24
4192373 | NK03.04.3024 | 3024 | 2.24
4192390 | NK03.04.3025 | 3025 | 2.25
4192405 | NK03.04.3026 | 3026 | 2.25
4192444 | NK03.04.3027 | 3027 | 2.26
4192471 | NK03.04.3028 | 3028 | 2.26
4192500 | NK03.04.3029 | 3029 | 2.27
4208357 | NK03.04.3030 | 3030 | 2.11

# IfcFurniture: Sedačka:SN01B_Sedačka, Sedačka:SN01B_Sedačka:4163070
In: SO103-1NP
Type - Classification: SN Stěny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01B; Konstrukce / Materiály: Dvojmístné křeslo, 4-nohá dřevěná podnož ze světlého masivního dřeva, bez kluzáků, hmotnost 24 kg, celočalouněný korpus. Tloušťka opěráku 30 mm, tloušťka sedáku 35 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Sedačka; Rozměry: 1320/760/760 mm (š/h/v); viz nákres
KIC_PSet - Kód prvku: NK07.01B.3001; Označení: 3001; Podlaží: SO103-1NP; Číslo místnosti: 1.02B

# IfcFurniture: Sedačka:SN01C_Sedačka, Sedačka:SN01C_Sedačka:4194895
In: SO103-2NP
Type - Classification: SN Stěny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01C; Konstrukce / Materiály: Dvojmístné křeslo, 4-nohá dřevěná podnož ze světlého masivního dřeva, bez kluzáků, hmotnost 24 kg, celočalouněný korpus. Tloušťka opěráku 30 mm, tloušťka sedáku 35 mm, materíál: 100% polyester, gramáž: 400g/m2; Typ nábytku: Sedačka; Rozměry: 1320/760/760 mm (š/h/v); viz nákres
KIC_PSet - Kód prvku: NK07.01C.3001; Označení: 3001; Podlaží: SO103-2NP; Číslo místnosti: 2.01B

# IfcFurniture: Skříň kancelářská vysoká:SK02_Skříň kancelářská vysoká (43)
In: SO103-2NP
Type - Classification: SK Střešní krytiny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm; Typ nábytku: Skříň kancelářská vysoká; Rozměry: 800/470/2100 mm (š/h/v)
KIC_PSet - Podlaží: SO103-2NP
Name (Skříň kancelářská vysoká:SK02_Skříň kancelářská vysoká:...) | Kód prvku | Označení | Číslo místnosti
4185478 | NK10.02.3001 | 3001 | 2.04
4185502 | NK10.02.3002 | 3002 | 2.04
4185514 | NK10.02.3003 | 3003 | 2.04
4185572 | NK10.02.3007 | 3007 | 2.05
4185573 | NK10.02.3008 | 3008 | 2.05
4185574 | NK10.02.3009 | 3009 | 2.05
4185612 | NK10.02.3013 | 3013 | 2.06
4185613 | NK10.02.3014 | 3014 | 2.06
4185614 | NK10.02.3015 | 3015 | 2.06
4185640 | NK10.02.3016 | 3016 | 2.06
4189180 | NK10.02.3019 | 3019 | 2.09
4189181 | NK10.02.3020 | 3020 | 2.09
4189215 | NK10.02.3021 | 3021 | 2.10
4189257 | NK10.02.3022 | 3022 | 2.10
4189301 | NK10.02.3023 | 3023 | 2.10
4189503 | NK10.02.3025 | 3025 | 2.11
4189504 | NK10.02.3026 | 3026 | 2.11
4189592 | NK10.02.3031 | 3031 | 2.12
4189593 | NK10.02.3032 | 3032 | 2.12
4189675 | NK10.02.3035 | 3035 | 2.13
4189795 | NK10.02.3036 | 3036 | 2.13
4190166 | NK10.02.3039 | 3039 | 2.15
4190167 | NK10.02.3040 | 3040 | 2.15
4190444 | NK10.02.3045 | 3045 | 2.16
4190445 | NK10.02.3046 | 3046 | 2.16
4190605 | NK10.02.3049 | 3049 | 2.17
4190606 | NK10.02.3050 | 3050 | 2.17
4191200 | NK10.02.3053 | 3053 | 2.22
4191201 | NK10.02.3054 | 3054 | 2.22
4191242 | NK10.02.3057 | 3057 | 2.23
4191243 | NK10.02.3058 | 3058 | 2.23
4191294 | NK10.02.3059 | 3059 | 2.18
4191295 | NK10.02.3060 | 3060 | 2.18
4191327 | NK10.02.3061 | 3061 | 2.25
4191328 | NK10.02.3062 | 3062 | 2.25
4191573 | NK10.02.3072 | 3072 | 2.27
4191574 | NK10.02.3073 | 3073 | 2.27
4191590 | NK10.02.3074 | 3074 | 2.27
4191666 | NK10.02.3075 | 3075 | 2.27
4191702 | NK10.02.3076 | 3076 | 2.27
4191716 | NK10.02.3077 | 3077 | 2.27
4191726 | NK10.02.3078 | 3078 | 2.27
4230476 | NK10.02.3079 | 3079 | 2.04

# IfcFurniture: Skříň kancelářská vysoká:SK02_Skříň kancelářská vysoká (37)
In: SO103-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm; Typ nábytku: Skříň kancelářská vysoká; Rozměry: 800/470/2100 mm (š/h/v)
Classification: SK Střešní krytiny (Uniformat)
KIC_PSet - Podlaží: SO103-2NP
Name (Skříň kancelářská vysoká:SK02_Skříň kancelářská vysoká:...) | Kód prvku | Označení | Číslo místnosti
4185544 | NK10.02.3004 | 3004 | 2.04
4185545 | NK10.02.3005 | 3005 | 2.04
4185546 | NK10.02.3006 | 3006 | 2.04
4185594 | NK10.02.3010 | 3010 | 2.05
4185595 | NK10.02.3011 | 3011 | 2.05
4185596 | NK10.02.3012 | 3012 | 2.05
4189147 | NK10.02.3017 | 3017 | 2.09
4189148 | NK10.02.3018 | 3018 | 2.09
4189329 | NK10.02.3024 | 3024 | 2.10
4189520 | NK10.02.3027 | 3027 | 2.11
4189521 | NK10.02.3028 | 3028 | 2.11
4189565 | NK10.02.3029 | 3029 | 2.12
4189566 | NK10.02.3030 | 3030 | 2.12
4189626 | NK10.02.3033 | 3033 | 2.13
4189627 | NK10.02.3034 | 3034 | 2.13
4189959 | NK10.02.3037 | 3037 | 2.14
4189960 | NK10.02.3038 | 3038 | 2.14
4190205 | NK10.02.3041 | 3041 | 2.15
4190206 | NK10.02.3042 | 3042 | 2.15
4190332 | NK10.02.3043 | 3043 | 2.16
4190333 | NK10.02.3044 | 3044 | 2.16
4190555 | NK10.02.3047 | 3047 | 2.17
4190556 | NK10.02.3048 | 3048 | 2.17
4191171 | NK10.02.3051 | 3051 | 2.22
4191172 | NK10.02.3052 | 3052 | 2.22
4191217 | NK10.02.3055 | 3055 | 2.23
4191218 | NK10.02.3056 | 3056 | 2.23
4191350 | NK10.02.3063 | 3063 | 2.24
4191351 | NK10.02.3064 | 3064 | 2.24
4191364 | NK10.02.3065 | 3065 | 2.24
4191437 | NK10.02.3066 | 3066 | 2.25
4191438 | NK10.02.3067 | 3067 | 2.25
4191539 | NK10.02.3068 | 3068 | 2.26
4191540 | NK10.02.3069 | 3069 | 2.26
4191548 | NK10.02.3070 | 3070 | 2.26
4191549 | NK10.02.3071 | 3071 | 2.26
4235946 | NK10.02.3080 | 3080 | 2.24

# IfcFurniture: Skříň šatní:SK01_Skříň šatní (40)
In: SO103-2NP
Type - Classification: SK Střešní krytiny (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm. Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm; Typ nábytku: Skříň šatní; Rozměry: 600/470/2100 mm (š/h/v)
KIC_PSet - Podlaží: SO103-2NP
Name (Skříň šatní:SK01_Skříň šatní:...) | Kód prvku | Označení | Číslo místnosti
4186706 | NK10.01.3001 | 3001 | 2.04
4186776 | NK10.01.3002 | 3002 | 2.04
4186804 | NK10.01.3003 | 3003 | 2.04
4186825 | NK10.01.3004 | 3004 | 2.05
4186826 | NK10.01.3005 | 3005 | 2.05
4186827 | NK10.01.3006 | 3006 | 2.05
4186858 | NK10.01.3007 | 3007 | 2.06
4186860 | NK10.01.3008 | 3008 | 2.06
4189339 | NK10.01.3009 | 3009 | 2.09
4189370 | NK10.01.3010 | 3010 | 2.09
4189400 | NK10.01.3011 | 3011 | 2.10
4189433 | NK10.01.3012 | 3012 | 2.10
4189473 | NK10.01.3013 | 3013 | 2.11
4189483 | NK10.01.3014 | 3014 | 2.11
4189539 | NK10.01.3015 | 3015 | 2.12
4189645 | NK10.01.3016 | 3016 | 2.13
4190036 | NK10.01.3017 | 3017 | 2.14
4190069 | NK10.01.3018 | 3018 | 2.14
4190128 | NK10.01.3019 | 3019 | 2.15
4190136 | NK10.01.3020 | 3020 | 2.15
4190357 | NK10.01.3021 | 3021 | 2.16
4190427 | NK10.01.3022 | 3022 | 2.16
4190536 | NK10.01.3023 | 3023 | 2.17
4190537 | NK10.01.3024 | 3024 | 2.17
4191129 | NK10.01.3025 | 3025 | 2.22
4191149 | NK10.01.3026 | 3026 | 2.22
4191272 | NK10.01.3027 | 3027 | 2.23
4191273 | NK10.01.3028 | 3028 | 2.23
4191397 | NK10.01.3029 | 3029 | 2.24
4191398 | NK10.01.3030 | 3030 | 2.24
4191416 | NK10.01.3031 | 3031 | 2.25
4191417 | NK10.01.3032 | 3032 | 2.25
4191520 | NK10.01.3033 | 3033 | 2.26
4191521 | NK10.01.3034 | 3034 | 2.26
4191612 | NK10.01.3035 | 3035 | 2.27
4191613 | NK10.01.3036 | 3036 | 2.27
4191627 | NK10.01.3037 | 3037 | 2.27
4212825 | NK10.01.3038 | 3038 | 2.06
4214646 | NK10.01.3039 | 3039 | 2.13
4248589 | NK10.01.3040 | 3040 | 2.10

# IfcFurniture: Sprchová stolička:P15_Sprchová stolička (4)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 15; Konstrukce / Materiály: Konstrukce z plastu - akrylátu s otvory pro manipulaci, nosnost 130 kg; Typ nábytku: Sprchová stolička; Rozměry: 330/275/480 mm (š/h/v)
Name (Sprchová stolička:P15_Sprchová stolička:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4176414 | SO103-1NP | NK18.15.3001 | 3001 | SO103-1NP | 1.18
4179043 | SO103-1NP | NK18.15.3002 | 3002 | SO103-1NP | 1.20
4180446 | SO103-2NP | NK18.15.3003 | 3003 | SO103-2NP | 2.19
4180471 | SO103-2NP | NK18.15.3004 | 3004 | SO103-2NP | 2.21

# IfcFurniture: Stůl exteriérový:EN02_Stůl exteriérový (3)
In: SO103-2NP
Type - Classification: EN (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 02; Konstrukce / Materiály: Konstrukce ocelová pozinkovaná a ošetřená barvou v laku. Podnož tříramenná. Hmotnost: 6,3 kg. Vhodný pro venkovní použití.; Typ nábytku: Stůl exteriérový; Rozměry: 600/720 mm (Ø/v)
KIC_PSet - Podlaží: SO103-2NP; Číslo místnosti: 2.29
Name (Stůl exteriérový:EN02_Stůl exteriérový:...) | Kód prvku | Označení
4196025 | NK11.02.3001 | 3001
4204170 | NK11.02.3002 | 3002
4204180 | NK11.02.3003 | 3003

# IfcFurniture: Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1 (26)
In: SO103-2NP
Type - Classification: KK (Uniformat); Material: <Unnamed>, Plast černý
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm, Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm. Vysunutí zásuvky max. na 75% hloubky. Kontejner je opatřen zámkovým systémem, který centrálně uzavírá a otevírá všechny zásuvky kontejneru a současně blokuje výsuv více než jedné zásuvky.; Typ nábytku: Uzamykatelný mobilní kontejner 3+1; Rozměry: 443/600/602 mm (š/h/v)
KIC_PSet - Podlaží: SO103-2NP
Name (Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1:...) | Kód prvku | Označení | Číslo místnosti
4207796 | NK13.01.3002 | 3002 | 2.04
4207809 | NK13.01.3003 | 3003 | 2.04
4207848 | NK13.01.3005 | 3005 | 2.05
4207873 | NK13.01.3006 | 3006 | 2.05
4208057 | NK13.01.3008 | 3008 | 2.06
4208088 | NK13.01.3009 | 3009 | 2.06
4208317 | NK13.01.3011 | 3011 | 2.10
4208361 | NK13.01.3012 | 3012 | 2.11
4208406 | NK13.01.3013 | 3013 | 2.12
4208507 | NK13.01.3015 | 3015 | 2.09
4208564 | NK13.01.3019 | 3019 | 2.27
4208633 | NK13.01.3021 | 3021 | 2.26
4208677 | NK13.01.3023 | 3023 | 2.25
4208891 | NK13.01.3025 | 3025 | 2.24
4208997 | NK13.01.3027 | 3027 | 2.23
4209123 | NK13.01.3029 | 3029 | 2.22
4215069 | NK13.01.3031 | 3031 | 2.13
4215095 | NK13.01.3032 | 3032 | 2.13
4215396 | NK13.01.3033 | 3033 | 2.14
4215421 | NK13.01.3034 | 3034 | 2.14
4215471 | NK13.01.3035 | 3035 | 2.15
4215501 | NK13.01.3036 | 3036 | 2.15
4215745 | NK13.01.3037 | 3037 | 2.16
4215759 | NK13.01.3038 | 3038 | 2.16
4215902 | NK13.01.3039 | 3039 | 2.17
4215920 | NK13.01.3040 | 3040 | 2.17

# IfcFurniture: Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1 (14)
In: SO103-2NP
Type - Material: <Unnamed>, Plast černý
Type - KIC_PSet - Označení typu: 01; Konstrukce / Materiály: Materiál korpusu: dřevotřísková deska s melaminovým potahem, tl. 18 mm, Zadní čelo: dřevotřísková deska s melaminovým potahem, tl. 8 mm. Vysunutí zásuvky max. na 75% hloubky. Kontejner je opatřen zámkovým systémem, který centrálně uzavírá a otevírá všechny zásuvky kontejneru a současně blokuje výsuv více než jedné zásuvky.; Typ nábytku: Uzamykatelný mobilní kontejner 3+1; Rozměry: 443/600/602 mm (š/h/v)
Classification: KK (Uniformat)
KIC_PSet - Podlaží: SO103-2NP
Name (Uzamykatelný mobilní kontejner:KK01_Uzamykatelný mobilní kontejner 3+1:...) | Kód prvku | Označení | Číslo místnosti
4207760 | NK13.01.3001 | 3001 | 2.04
4207844 | NK13.01.3004 | 3004 | 2.05
4208053 | NK13.01.3007 | 3007 | 2.06
4208232 | NK13.01.3010 | 3010 | 2.09
4208465 | NK13.01.3014 | 3014 | 2.12
4208527 | NK13.01.3016 | 3016 | 2.10
4208543 | NK13.01.3017 | 3017 | 2.11
4208560 | NK13.01.3018 | 3018 | 2.27
4208611 | NK13.01.3020 | 3020 | 2.27
4208655 | NK13.01.3022 | 3022 | 2.26
4208863 | NK13.01.3024 | 3024 | 2.25
4208947 | NK13.01.3026 | 3026 | 2.24
4209047 | NK13.01.3028 | 3028 | 2.23
4209149 | NK13.01.3030 | 3030 | 2.22

# IfcFurniture: Věšák stojanový:P14_Věšák stojanový (2)
Type - Classification: P (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 14; Konstrukce / Materiály: Konstrukce z masivního dřeva světlé barvy; Typ nábytku: Věšák stojanový; Rozměry: 510/1760 mm (Ø/v)
Name (Věšák stojanový:P14_Věšák stojanový:...) | In | Kód prvku | Označení | Podlaží | Číslo místnosti
4165144 | SO103-1NP | NK17.14.3001 | 3001 | SO103-1NP | 1.02C
4207669 | SO103-2NP | NK17.14.3003 | 3003 | SO103-2NP | 2.01C

# IfcFurniture: Věšák stojanový:P14_Věšák stojanový, Věšák stojanový:P14_Věšák stojanový:4192569
In: SO103-2NP
Type - Material: <Unnamed>
Type - KIC_PSet - Označení typu: 14; Konstrukce / Materiály: Konstrukce z masivního dřeva světlé barvy; Typ nábytku: Věšák stojanový; Rozměry: 510/1760 mm (Ø/v)
Classification: P (Uniformat)
KIC_PSet - Kód prvku: NK17.14.3002; Označení: 3002; Podlaží: SO103-2NP; Číslo místnosti: 2.18

# IfcFurniture: Židle jídelní barová exteriérová:EN04_Židle jídelní barová exteriérová (6)
In: SO103-2NP
Type - Classification: EN (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 04; Konstrukce / Materiály: Konstrukce židle z pozinkované oceli ošetřené práškovou barvou. Hmtnost: 6,1 kg, vhodná pro venkovní použití.; Typ nábytku: Židle barová exteriérová; Rozměry: 465/490/960 mm (š/h/v); výška sedáku: 750 mm
KIC_PSet - Podlaží: SO103-2NP; Číslo místnosti: 2.29
Name (Židle jídelní barová exteriérová:EN04_Židle jídelní barová exteriérová:...) | Kód prvku | Označení
4197958 | NK12.04.3008 | 3008
4204112 | NK12.04.3009 | 3009
4204138 | NK12.04.3010 | 3010
4204139 | NK12.04.3011 | 3011
4204149 | NK12.04.3012 | 3012
4204150 | NK12.04.3013 | 3013

# IfcFurniture: Židle jídelní exteriérová:EN03_Židle jídelní exteriérová (11)
In: SO103-2NP
Type - Classification: EN (Uniformat); Material: <Unnamed>
Type - KIC_PSet - Označení typu: 03; Konstrukce / Materiály: Konstrukce židle z pozinkované oceli ošetřené práškovou barvou. Hmtnost: 5,6 kg. Stohovatelnost: po 10 ks, vhodná pro venkovní použití.; Typ nábytku: Židle jídelní exteriérová; Rozměry: 520/575/800 mm (š/h/v)
KIC_PSet - Podlaží: SO103-2NP; Číslo místnosti: 2.29
Name (Židle jídelní exteriérová:EN03_Židle jídelní exteriérová:...) | Kód prvku | Označení
4198976 | NK12.03.3001 | 3001
4204283 | NK12.03.3002 | 3002
4204342 | NK12.03.3003 | 3003
4204405 | NK12.03.3004 | 3004
4204417 | NK12.03.3005 | 3005
4204418 | NK12.03.3006 | 3006
4204419 | NK12.03.3007 | 3007
4204420 | NK12.03.3008 | 3008
4204441 | NK12.03.3009 | 3009
4204442 | NK12.03.3010 | 3010
4204443 | NK12.03.3011 | 3011
